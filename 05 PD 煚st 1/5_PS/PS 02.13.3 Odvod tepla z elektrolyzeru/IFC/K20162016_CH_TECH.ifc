Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: ZDE ZADEJTE ČÍSLO PROJEKTU
Time: 2021-05-27T13:13:04
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 21.1.11.27 - Exporter 21.1.11.27 - IFC Model Exchange with Archicad 24.0.0.4000

# IfcProject, ZDE ZADEJTE ČÍSLO PROJEKTU
LongName: ZDE ZADEJTE NÁZEV PROJEKTU; Phase: ZDE ZADEJTE STUPEŇ PD

# IfcSite, Default
RefLatitude: 50, 4, 59, 999999; RefLongitude: 14, 24, 59, 999999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey (5)
Name | LongName | Elevation (mm)
1NP-CH | 1NP-CH | 0
2NP-CH | 2NP-CH | 3800
NEHMOTNÉ POLOŽKY | NEHMOTNÉ POLOŽKY | -7000
4NP-CH | 4NP-CH | 11250
5NP_CH | 5NP_CH | 14900

# IfcBuildingStorey: Podlaží:Podlaží, 3NP-CH
LongName: 3NP-CH; Elevation: 7600 mm

# IfcCovering: Izolace trubky:IZOLACE_KAUČUK 20 mm (127)
In: 3NP-CH
PredefinedType: INSULATION; Classification: IT.01 Tepelná (Default Classification); Izolace (Uniformat)
Pset_CoveringCommon - Reference: IZOLACE_KAUČUK 20 mm; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Izolace; SNIM: IT.01 Tepelná
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Izolace trubky:IZOLACE_KAUČUK 20 mm:...)
2114157
2114158
2114159
2114162
2114163
2114164
2114165
2114166
2114167
2114168
2114169
2114170
2114171
2114173
2114174
2114175
2114176
2114177
2114178
2114179
2114180
2114181
2114182
2114183
2114184
2114185
2114187
2114188
2114189
2114191
2114192
2114193
2114194
2114195
2114196
2114197
2114198
2114199
2114201
2114202
2114203
2114204
2114205
2114206
2114207
2114208
2114209
2114211
2114212
2114213
2114214
2114215
2114216
2114217
2114218
2114219
2114220
2114221
2114222
2114223
2114224
2114225
2114226
2114227
2114228
2114229
2114230
2114231
2114232
2114233
2114234
2114989
2115035
2115036
2115037
2115038
2115039
2115040
2115041
2115042
2115043
2115044
2115289
2115315
2115316
2115317
2115318
2115319
2115320
2115321
2115322
2115323
2115909
2115910
2115911
2116094
2116095
2116096
2116649
2116650
2116651
2116652
2116653
2116654
2116656
2116657
2116660
2116661
2117226
2117227
2117228
2117808
2117809
2117810
2117811
2117812
2117813
2117814
2117815
2117816
2117817
2118159
2118160
2118161
2118259
2118288
2120256

# IfcDistributionPort (460)
Name | Description | FlowDirection | Group | PortNumber | ConnectionType | ProfileShape | OuterDiameter (mm) | ConnectorDiameter (mm) = NominalWidth (mm) = NominalHeight (mm)
InPort_2100648 | Flow | SOURCEANDSINK | CH_PRIVOD 1
OutPort_2103003 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 50
InPort_2100648 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2120259 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2101637 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2102420 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 40 | 32
InPort_2101637 | Flow | SOURCEANDSINK | CH_PRIVOD 1
OutPort_2102331 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 40 | 32
InPort_2104087 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2102188 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2102188 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2103048 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2102295 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103003 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2102295 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2102475 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102331 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 40 | 32
OutPort_2104029 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 32 | 32
InPort_2102420 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 40 | 32
OutPort_2120317 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2102420 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 40 | 32
OutPort_2105564 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 32 | 32
InPort_2102475 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2102477 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102477 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2103076 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102577 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2102916 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102577 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2103539 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
InPort_2102579 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2120250 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102579 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117654 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102879 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2102901 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102879 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2102916 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2102893 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103501 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
InPort_2102893 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2102999 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102901 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2103557 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102916 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2102927 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102927 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117424 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2102987 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2102995 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102987 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2102999 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2102995 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2103481 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2102995 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2103088 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2103015 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103078 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2120695 | Flow | SINK | CH_PRIVOD 1
OutPort_2103015 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2103015 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2103076 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2103027 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2115877 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2103027 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2103078 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2103167 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103048 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2103048 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2103049 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
Port_2103049 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2103088 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2106643 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2103097 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2106837 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2103097 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2106643 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2103720 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103165 | Flow | SOURCE | CH_PRIVOD 1
InPort_2103165 | Flow | SINK | CH_PRIVOD 1
OutPort_2103167 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
2 x InPort_2103479 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2104773 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103481 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2103501 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2104904 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2103539 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2103541 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2103541 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2104780 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
2 x InPort_2103555 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2103557 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2104928 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2114981 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2103718 | Flow | SOURCE | CH_PRIVOD 1
InPort_2103718 | Flow | SINK | CH_PRIVOD 1
OutPort_2114853 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2114760 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2103720 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2104019 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2104079 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2104019 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2118257 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 32 | 32
InPort_2104029 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 40 | 32
OutPort_2118257 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2104033 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2104075 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2104033 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2104079 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2120668 | Flow | SINK | CH_PRIVOD 1
OutPort_2104033 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 63 | 50
InPort_2104071 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2104075 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2104071 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2116062 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2104422 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2104087 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2106937 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2104087 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 63 | 50
InPort_2115281 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2104186 | Flow | SOURCE | CH_PRIVOD 1
InPort_2104186 | Flow | SINK | CH_PRIVOD 1
OutPort_2115187 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2115091 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2104223 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2104223 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2104401 | Flow | SOURCE | CH_PRIVOD 1
InPort_2104401 | Flow | SINK | CH_PRIVOD 1
OutPort_2104422 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
2 x InPort_2104771 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2104775 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
OutPort_2104780 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 20
InPort_2104773 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2104775 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 20
2 x InPort_2104792 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2104921 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 20
OutPort_2104938 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 20
InPort_2104904 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2104921 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2104928 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2104938 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2105560 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2105621 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105560 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105801 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
InPort_2105564 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 40 | 32
OutPort_2118286 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 32 | 32
InPort_2105598 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2105662 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105598 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105621 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2105621 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2116589 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105632 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2116245 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2105632 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2118286 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2105654 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2105755 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
InPort_2105654 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105680 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105662 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105819 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105664 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2105680 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2105664 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105676 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105676 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105677 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105676 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2105741 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105677 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2106837 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
2 x InPort_2105739 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2105741 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105931 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105755 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2106062 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105801 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2105803 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105803 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105938 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
2 x InPort_2105817 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2106038 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
OutPort_2105819 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
2 x InPort_2105929 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2105938 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 25 | 25
OutPort_2105933 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2105931 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2105933 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 25 | 25
2 x InPort_2105950 | Flow | SOURCEANDSINK | CH_ZPATECKA 1
OutPort_2106072 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 25 | 25
OutPort_2106055 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 25 | 25
InPort_2106038 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2106055 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2106062 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2106072 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2106643 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2106644 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
Port_2106644 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2106837 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2106921 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2106919 | Flow | SINK | CH_ZPATECKA 1
OutPort_2114246 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2106921 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2106919 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2114248 | Flow | SINK | CH_PRIVOD 1
OutPort_2106935 | Flow | SOURCE | CH_PRIVOD 1
InPort_2106935 | Flow | SINK | CH_PRIVOD 1
OutPort_2106937 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2114735 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2114760 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2114906 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2114735 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2114853 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2114760 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 50 | 40
InPort_2115459 | Flow | SINK | CH_PRIVOD 1
OutPort_2114890 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2114890 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2114906 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2115026 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2114946 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2114946 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2114974 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2114974 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2114981 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2114974 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2115888 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2115617 | Flow | SINK | CH_PRIVOD 1
OutPort_2115018 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2115018 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2115026 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2115219 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2115066 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2115066 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2115091 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2115187 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2115091 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 63 | 50
InPort_2115678 | Flow | SINK | CH_PRIVOD 1
OutPort_2115211 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2115211 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2115219 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2115245 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2115274 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2115306 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2115245 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2115274 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2115281 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2115274 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2116073 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2115733 | Flow | SINK | CH_PRIVOD 1
OutPort_2115298 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2115298 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2115306 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2115990 | Flow | SINK | CH_PRIVOD 1
OutPort_2115851 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2115851 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2115877 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2115877 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2115888 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2116040 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2116062 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2116172 | Flow | SINK | CH_PRIVOD 1
OutPort_2116040 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2116062 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2116073 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2116245 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2116220 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2116220 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2116719 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2116245 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2116256 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2116256 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2116298 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2116298 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2116269 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2116269 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2116640 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2116298 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
OutPort_2116406 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 63 | 50
InPort_2116406 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2116443 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2116443 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
OutPort_2116589 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 63 | 50
InPort_2116977 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2116443 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 63 | 50
InPort_2116640 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2116632 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2116632 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2116902 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2116719 | Flow | SINK | CH_ZPATECKA 1
OutPort_2116220 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2116902 | Flow | SINK | CH_ZPATECKA 1
OutPort_2116632 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2117015 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2116977 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2116989 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2117015 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
2 x InPort_2117166 | Flow | SINK | CH_ZPATECKA 1
OutPort_2116989 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2118210 | Flow | SINK | CH_ZPATECKA 1
OutPort_2117166 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2117424 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117435 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2118032 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2117424 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 50 | 40
InPort_2117435 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117477 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2117477 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117450 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2117450 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2117799 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2117477 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2117488 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 50 | 40
InPort_2117488 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117528 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2117501 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2117890 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2117528 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2117501 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2117528 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2117654 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
InPort_2117791 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2117977 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2117799 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2117791 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2117890 | Flow | SINK | CH_ZPATECKA 1
OutPort_2117501 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2117977 | Flow | SINK | CH_ZPATECKA 1
OutPort_2117791 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2118048 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2118032 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
2 x InPort_2118105 | Flow | SINK | CH_ZPATECKA 1
OutPort_2118040 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2118040 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2118048 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2118197 | Flow | SINK | CH_ZPATECKA 1
OutPort_2118105 | Flow | SOURCE | CH_ZPATECKA 1
OutPort_2118197 | Flow | SOURCE | CH_ZPATECKA 1
OutPort_2118210 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2120250 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 40
OutPort_2120259 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 50 | 50
InPort_2120250 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 3 | WELDED | ROUND | 50 | 40
OutPort_2120284 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2120284 | Flow | SINK | CH_ZPATECKA 1
OutPort_2120274 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2120274 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2120544 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2120317 | Flow | SINK | CH_ZPATECKA 1
OutPort_2120309 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2120309 | Flow | SOURCEANDSINK | CH_ZPATECKA 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2120396 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2120396 | Flow | SINK | CH_ZPATECKA 1
OutPort_2120463 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2120544 | Flow | SINK | CH_ZPATECKA 1
OutPort_2120607 | Flow | SOURCE | CH_ZPATECKA 1
InPort_2120660 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
OutPort_2120668 | Flow | SOURCE | CH_PRIVOD 1
InPort_2120764 | Flow | SINK | CH_PRIVOD 1
OutPort_2120660 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
InPort_2120705 | Flow | SINK | CH_PRIVOD 1
OutPort_2120687 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 1 | WELDED | ROUND | 20 | 15
InPort_2120687 | Flow | SOURCEANDSINK | CH_PRIVOD 1 | 2 | WELDED | ROUND | 20 | 15
OutPort_2120695 | Flow | SOURCE | CH_PRIVOD 1
InPort_2120750 | Flow | SINK | CH_PRIVOD 1
OutPort_2120705 | Flow | SOURCE | CH_PRIVOD 1
InPort_2120824 | Flow | SINK | CH_PRIVOD 1
OutPort_2120764 | Flow | SOURCE | CH_PRIVOD 1
5 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 50 | 50
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 50 | 50
 |  | SOURCEANDSINK |  | 3 | WELDED | ROUND | 50 | 50
 |  | SOURCEANDSINK |  | 4 | WELDED | ROUND | 50 | 50
 |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 32 | 32
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 40 | 32
 |  | SOURCEANDSINK |  | 3 | WELDED | ROUND | 32 | 32
 |  | SOURCEANDSINK |  | 4 | WELDED | ROUND | 40 | 32
5 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 50 | 40
5 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 50 | 40
 |  | SINK |  | 1 | WELDED | ROUND | 50 | 40
 |  | SOURCE |  | 2 | WELDED | ROUND | 50 | 40
 |  | SINK |  | 1 | WELDED | ROUND | 63 | 50
 |  | SOURCE |  | 2 | WELDED | ROUND | 63 | 50
5 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 63 | 50
7 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 63 | 50
2 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 20 | 20
2 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 20 | 20
2 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 25 | 25
2 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 25 | 25
12 x  |  | SINK |  | 1 | WELDED | ROUND | 20 | 15
2 x  |  | SOURCE |  | 2 | WELDED | ROUND | 15 | 15
10 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 15 | 15
4 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 20 | 15
2 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 50 | 15
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 40 | 15
4 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 20 | 15
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 63 | 15

# IfcEnergyConversionDevice: Výměník AEM elektrolyzery 15kW (T5_MFG)EP:Výměník AEM elektrolyzery 15kW (T5_MFG)EP, Výměník AEM elektrolyzery 15kW (T5_MFG)EP:Výměník AEM elektrolyzery 15kW (T5_MFG)EP:2100648
In: 3NP-CH
Type - Pset_BuildingElementProxyCommon - Reference: Výměník AEM elektrolyzery 15kW (T5_MFG)EP
Type - Pset_QuantityTakeOff - Reference: Výměník AEM elektrolyzery 15kW (T5_MFG)EP
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 105.683 mm; Depth: 105.683 mm
REVIT Klasifikace - OZNAČENÍ: Výměník; SNIM: VI.02 Deskový rozebíratelný
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: CH_ZPATECKA 1; CH_PRIVOD 1

# IfcEnergyConversionDevice: Výměník PEM elektrolyzery 25kW (TL3_PFG)EP:Výměník PEM elektrolyzery 25kW (TL3_PFG)EP, Výměník PEM elektrolyzery 25kW (TL3_PFG)EP:Výměník PEM elektrolyzery 25kW (TL3_PFG)EP:2101637
In: 3NP-CH
Type - Pset_BuildingElementProxyCommon - Reference: Výměník PEM elektrolyzery 25kW (TL3_PFG)EP
Type - Pset_QuantityTakeOff - Reference: Výměník PEM elektrolyzery 25kW (TL3_PFG)EP
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 25 mm; Depth: 25 mm
REVIT Klasifikace - OZNAČENÍ: Výměník; SNIM: VI.02 Deskový rozebíratelný
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: CH_ZPATECKA 1; CH_PRIVOD 1

# IfcFlowFitting: PP_Fiber Bazalt_Odbočka_EP:PP (20)
In: 3NP-CH
Type - Material: Trubky_PP R Instaplast PN16
Type - Pset_DistributionFlowElementCommon - Reference: PP
Type - Pset_QuantityTakeOff - Reference: PP
Classification: Trubní tvarovka (Uniformat); TT.02 Odbočka (Default Classification)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.02 Odbočka
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (PP_Fiber Bazalt_Odbočka_EP:PP:...) | Group
2102916 | CH_ZPATECKA 1
2102995 | CH_ZPATECKA 1
2103048 | CH_PRIVOD 1
2104087 | CH_PRIVOD 1
2105621 | CH_ZPATECKA 1
2105676 | CH_ZPATECKA 1
2106643 | CH_ZPATECKA 1
2106837 | CH_ZPATECKA 1
2114760 | CH_PRIVOD 1
2114974 | CH_PRIVOD 1
2115091 | CH_PRIVOD 1
2115274 | CH_PRIVOD 1
2115877 | CH_PRIVOD 1
2116062 | CH_PRIVOD 1
2116245 | CH_ZPATECKA 1
2116298 | CH_ZPATECKA 1
2116443 | CH_ZPATECKA 1
2117424 | CH_ZPATECKA 1
2117477 | CH_ZPATECKA 1
2117528 | CH_ZPATECKA 1

# IfcFlowFitting: PP_Fiber Bazalt_Redukce_EP:PP (12)
In: 3NP-CH
Type - Material: Trubky_PP R Instaplast PN16
Type - Pset_DistributionFlowElementCommon - Reference: PP
Type - Pset_QuantityTakeOff - Reference: PP
Classification: Trubní tvarovka (Uniformat); TT.03 Redukce (Default Classification)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.03 Redukce
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (PP_Fiber Bazalt_Redukce_EP:PP:...) | Group
2103003 | CH_PRIVOD 1
2104775 | CH_ZPATECKA 1
2104780 | CH_ZPATECKA 1
2104921 | CH_ZPATECKA 1
2104938 | CH_ZPATECKA 1
2105933 | CH_ZPATECKA 1
2105938 | CH_ZPATECKA 1
2106055 | CH_ZPATECKA 1
2106072 | CH_ZPATECKA 1
2118257 | CH_PRIVOD 1
2118286 | CH_ZPATECKA 1
2120259 | CH_ZPATECKA 1

# IfcFlowFitting: PP_Koleno:PP_Koleno (20)
In: 3NP-CH
Type - Material: Trubky_PP
Type - Pset_DistributionFlowElementCommon - Reference: PP_Koleno
Type - Pset_QuantityTakeOff - Reference: PP_Koleno
Classification: TT.01 Koleno (Default Classification); Trubní tvarovka (Uniformat)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.01 Koleno
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (PP_Koleno:PP_Koleno:...) | Group
2102475 | CH_PRIVOD 1
2102579 | CH_ZPATECKA 1
2102901 | CH_ZPATECKA 1
2102999 | CH_ZPATECKA 1
2103076 | CH_PRIVOD 1
2103078 | CH_PRIVOD 1
2104029 | CH_PRIVOD 1
2104075 | CH_PRIVOD 1
2104079 | CH_PRIVOD 1
2105564 | CH_ZPATECKA 1
2105662 | CH_ZPATECKA 1
2105680 | CH_ZPATECKA 1
2114906 | CH_PRIVOD 1
2115026 | CH_PRIVOD 1
2115219 | CH_PRIVOD 1
2115306 | CH_PRIVOD 1
2116640 | CH_ZPATECKA 1
2117015 | CH_ZPATECKA 1
2117799 | CH_ZPATECKA 1
2118048 | CH_ZPATECKA 1

# IfcFlowFitting: Pojistný ventil DN15_DN25_EP:DN15 (2)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: DN15
Type - Pset_ManufacturerTypeInformation - Manufacturer: Reliance Worldwide Corporation
Type - Pset_QuantityTakeOff - Reference: DN15
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil; SNIM: VE.09 Pojišťovací
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: CH_ZPATECKA 1
Name (Pojistný ventil DN15_DN25_EP:DN15:...)
2118105
2117166

# IfcFlowMovingDevice: Filtr_Závitový_EP:Závitový (2)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: Závitový
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Závitový
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Filtr; SNIM: FI.02 Mechanický
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: CH_PRIVOD 1
Name (Filtr_Závitový_EP:Závitový:...)
2103718
2104186

# IfcFlowMovingDevice: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout (12)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: Kulový kohout
Type - Pset_QuantityTakeOff - Reference: Kulový kohout
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil; SNIM: VE.01 Kulový kohout
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout:...) | Group
2103539 | CH_ZPATECKA 1
2103501 | CH_ZPATECKA 1
2103165 | CH_PRIVOD 1
2103479 | CH_ZPATECKA 1
2103555 | CH_ZPATECKA 1
2104401 | CH_PRIVOD 1
2105801 | CH_ZPATECKA 1
2105755 | CH_ZPATECKA 1
2105739 | CH_ZPATECKA 1
2105817 | CH_ZPATECKA 1
2106919 | CH_ZPATECKA 1
2106935 | CH_PRIVOD 1

# IfcFlowMovingDevice: Optima_compact_plus_10-32:OPTIMA Compact Plus DN20 M-M 5.0mm (2)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: OPTIMA Compact Plus DN20 M-M 5.0mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Hydronic Systems Prague s.r.o.
Type - Pset_QuantityTakeOff - Reference: OPTIMA Compact Plus DN20 M-M 5.0mm
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil; SNIM: VE.06 Regulační
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: CH_ZPATECKA 1
Name (Optima_compact_plus_10-32:OPTIMA Compact Plus DN20 M-M 5.0mm:...)
2104771
2104792

# IfcFlowMovingDevice: Optima_compact_plus_10-32:OPTIMA Compact Plus DN25 M-M 5.5mm (2)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: OPTIMA Compact Plus DN25 M-M 5.5mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Hydronic Systems Prague s.r.o.
Type - Pset_QuantityTakeOff - Reference: OPTIMA Compact Plus DN25 M-M 5.5mm
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil; SNIM: VE.06 Regulační
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: CH_ZPATECKA 1
Name (Optima_compact_plus_10-32:OPTIMA Compact Plus DN25 M-M 5.5mm:...)
2105929
2105950

# IfcFlowMovingDevice: PP_Návarek:PP (4)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: PP
Type - Pset_QuantityTakeOff - Reference: PP
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.08 Návarek
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (PP_Návarek:PP:...) | Group
2120695 | CH_PRIVOD 1
2120284 | CH_ZPATECKA 1
2120317 | CH_ZPATECKA 1
2120668 | CH_PRIVOD 1

# IfcFlowMovingDevice: Vypouštěcí kulový kohout_EP:vnitřní DN15 / vnější DN15 (4)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: vnitřní DN15 / vnější DN15
Type - Pset_QuantityTakeOff - Reference: vnitřní DN15 / vnější DN15
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil; SNIM: VE.12 Vypouštěcí
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Vypouštěcí kulový kohout_EP:vnitřní DN15 / vnější DN15:...) | Group
2120544 | CH_ZPATECKA 1
2120396 | CH_ZPATECKA 1
2120764 | CH_PRIVOD 1
2120705 | CH_PRIVOD 1

# IfcFlowSegment: FIBER BASALT CLIMA-Návarek (4)
In: 3NP-CH
Type - ElementType: FIBER BASALT CLIMA-Návarek; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 15; OuterDiameter: 20
Classification: TR.16 Kompozitní materiál (Default Classification); Trubka (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FIBER BASALT CLIMA-Návarek; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.16 Kompozitní materiál
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:FIBER BASALT CLIMA-Návarek:...) | Length (mm) | Group
2120274 | 65.8116 | CH_ZPATECKA 1
2120309 | 61.2175 | CH_ZPATECKA 1
2120660 | 34.75 | CH_PRIVOD 1
2120687 | 41.25 | CH_PRIVOD 1

# IfcFlowSegment: FIBER BASALT CLIMA-Tkus (20)
In: 3NP-CH
Type - ElementType: FIBER BASALT CLIMA-Tkus; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 15; OuterDiameter: 20
Classification: TR.16 Kompozitní materiál (Default Classification); Trubka (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FIBER BASALT CLIMA-Tkus; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.16 Kompozitní materiál
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:FIBER BASALT CLIMA-Tkus:...) | Length (mm) | Group
2114735 | 17.2 | CH_PRIVOD 1
2114890 | 22.2 | CH_PRIVOD 1
2114946 | 17.2 | CH_PRIVOD 1
2115018 | 22.2 | CH_PRIVOD 1
2115066 | 10.7 | CH_PRIVOD 1
2115211 | 22.2 | CH_PRIVOD 1
2115245 | 10.7 | CH_PRIVOD 1
2115298 | 22.2 | CH_PRIVOD 1
2115851 | 45 | CH_PRIVOD 1
2116040 | 38.5 | CH_PRIVOD 1
2116220 | 38.5 | CH_ZPATECKA 1
2116269 | 10.7 | CH_ZPATECKA 1
2116632 | 22.2 | CH_ZPATECKA 1
2116977 | 60.7 | CH_ZPATECKA 1
2116989 | 56.7 | CH_ZPATECKA 1
2117450 | 17.2 | CH_ZPATECKA 1
2117501 | 45 | CH_ZPATECKA 1
2117791 | 22.2 | CH_ZPATECKA 1
2118032 | 67.2 | CH_ZPATECKA 1
2118040 | 56.7 | CH_ZPATECKA 1

# IfcFlowSegment: FIBER BASALT CLIMA-Tkus (2)
In: 3NP-CH
Type - ElementType: FIBER BASALT CLIMA-Tkus; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 32; OuterDiameter: 40
Classification: TR.16 Kompozitní materiál (Default Classification); Trubka (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FIBER BASALT CLIMA-Tkus; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.16 Kompozitní materiál
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentPipeSegment - Length: 95.4516 mm
Name (Typy trubek:FIBER BASALT CLIMA-Tkus:...) | Group
2102331 | CH_PRIVOD 1
2102420 | CH_ZPATECKA 1

# IfcFlowSegment: FIBER BASALT CLIMA-Tkus (25)
In: 3NP-CH
Type - ElementType: FIBER BASALT CLIMA-Tkus; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 40; OuterDiameter: 50
Classification: TR.16 Kompozitní materiál (Default Classification); Trubka (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FIBER BASALT CLIMA-Tkus; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.16 Kompozitní materiál
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:FIBER BASALT CLIMA-Tkus:...) | Length (mm) | Group
2102295 | 117.665 | CH_PRIVOD 1
2102477 | 139.8 | CH_PRIVOD 1
2102577 | 104 | CH_ZPATECKA 1
2102879 | 39.9 | CH_ZPATECKA 1
2102893 | 53.9 | CH_ZPATECKA 1
2102927 | 20 | CH_ZPATECKA 1
2102987 | 39.9 | CH_ZPATECKA 1
2103015 | 139.8 | CH_PRIVOD 1
2103027 | 969.514 | CH_PRIVOD 1
2103088 | 83.5 | CH_ZPATECKA 1
2103167 | 147.5 | CH_PRIVOD 1
2103481 | 54 | CH_ZPATECKA 1
2103541 | 152.75 | CH_ZPATECKA 1
2103557 | 103.9 | CH_ZPATECKA 1
2103720 | 54 | CH_PRIVOD 1
2104773 | 152.75 | CH_ZPATECKA 1
2104904 | 132.75 | CH_ZPATECKA 1
2104928 | 132.75 | CH_ZPATECKA 1
2114853 | 17.75 | CH_PRIVOD 1
2114981 | 213.25 | CH_PRIVOD 1
2115888 | 190 | CH_PRIVOD 1
2117435 | 20 | CH_ZPATECKA 1
2117488 | 20 | CH_ZPATECKA 1
2117654 | 126.302 | CH_ZPATECKA 1
2120250 | 107.665 | CH_ZPATECKA 1

# IfcFlowSegment: FIBER BASALT CLIMA-Tkus (29)
In: 3NP-CH
Type - ElementType: FIBER BASALT CLIMA-Tkus; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 50; OuterDiameter: 63
Classification: TR.16 Kompozitní materiál (Default Classification); Trubka (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FIBER BASALT CLIMA-Tkus; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.16 Kompozitní materiál
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:FIBER BASALT CLIMA-Tkus:...) | Length (mm) | Group
2102188 | 699.528 | CH_PRIVOD 1
2103049 | 189.489 | CH_PRIVOD 1
2103097 | 699.528 | CH_ZPATECKA 1
2104019 | 94.85 | CH_PRIVOD 1
2104033 | 115.8 | CH_PRIVOD 1
2104071 | 1005.4 | CH_PRIVOD 1
2104223 | 40.8 | CH_PRIVOD 1
2104422 | 140.8 | CH_PRIVOD 1
2105560 | 90.8 | CH_ZPATECKA 1
2105598 | 21.4 | CH_ZPATECKA 1
2105632 | 26.4465 | CH_ZPATECKA 1
2105654 | 35.2 | CH_ZPATECKA 1
2105664 | 21.4 | CH_ZPATECKA 1
2105677 | 77 | CH_ZPATECKA 1
2105741 | 40.8 | CH_ZPATECKA 1
2105803 | 124.05 | CH_ZPATECKA 1
2105819 | 85.2 | CH_ZPATECKA 1
2105931 | 124.05 | CH_ZPATECKA 1
2106038 | 99.05 | CH_ZPATECKA 1
2106062 | 99.05 | CH_ZPATECKA 1
2106644 | 439.489 | CH_ZPATECKA 1
2106921 | 90.8 | CH_ZPATECKA 1
2106937 | 340.8 | CH_PRIVOD 1
2115187 | 5.75 | CH_PRIVOD 1
2115281 | 190.25 | CH_PRIVOD 1
2116073 | 177 | CH_PRIVOD 1
2116256 | 7 | CH_ZPATECKA 1
2116406 | 7 | CH_ZPATECKA 1
2116589 | 7 | CH_ZPATECKA 1

# IfcFlowTerminal: PP_Uzavření:PP_Uzavření (8)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: PP_Uzavření
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: PP_Uzavření
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.05 Záslepka
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (PP_Uzavření:PP_Uzavření:...) | Group
2118197 | CH_ZPATECKA 1
2114248 | CH_PRIVOD 1
2118210 | CH_ZPATECKA 1
2120463 | CH_ZPATECKA 1
2120607 | CH_ZPATECKA 1
2120750 | CH_PRIVOD 1
2120824 | CH_PRIVOD 1
2114246 | CH_ZPATECKA 1

# IfcFlowTerminal: Teploměr:Standardní (4)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Senzor; SNIM: SZ.04 Teploměr
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Teploměr:Standardní:...) | Group
2115990 | CH_PRIVOD 1
2116172 | CH_PRIVOD 1
2116719 | CH_ZPATECKA 1
2117890 | CH_ZPATECKA 1

# IfcFlowTerminal: Tlakoměr:Standardní (6)
In: 3NP-CH
Type - Pset_DistributionFlowElementCommon - Reference: Standardní
Type - Pset_QuantityTakeOff - Reference: Standardní
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Senzor; SNIM: SZ.05 Tlakoměr
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Tlakoměr:Standardní:...) | Group
2115459 | CH_PRIVOD 1
2115617 | CH_PRIVOD 1
2115678 | CH_PRIVOD 1
2115733 | CH_PRIVOD 1
2116902 | CH_ZPATECKA 1
2117977 | CH_ZPATECKA 1

# IfcBuildingElementProxyType, no part of this type: Výměník AEM elektrolyzery 15kW (T5_MFG)EP:Výměník AEM elektrolyzery 15kW (T5_MFG)EP
Material: Alfa_Laval_Alfa_Laval_T5_t5_Stainless_Steel

# IfcBuildingElementProxyType, no part of this type: Výměník PEM elektrolyzery 25kW (TL3_PFG)EP:Výměník PEM elektrolyzery 25kW (TL3_PFG)EP
Material: Stainless Steel

# IfcPipeFittingType, no part of this type: PP_Návarek:PP
Material: Trubky_PP

# IfcPipeFittingType, no part of this type: PP_Návarek:PP
Material: Trubky_PP

# IfcPipeFittingType, no part of this type: PP_Návarek:PP
Material: Trubky_PP

# IfcPipeFittingType, no part of this type: PP_Uzavření:PP_Uzavření
Material: Trubky_PP

# IfcPipeFittingType, no part of this type: PP_Uzavření:PP_Uzavření
Material: Trubky_PP

# IfcValveType, no part of this type: Filtr_Závitový_EP:Závitový
Material: <Unnamed> (2)

# IfcValveType, no part of this type: Filtr_Závitový_EP:Závitový
Material: <Unnamed> (2)

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio

# IfcValveType, no part of this type: Pojistný ventil DN15_DN25_EP:DN15
Classification: D2020300 Domestic Water Supply Equipment (Uniformat); Material: RWC Brass
