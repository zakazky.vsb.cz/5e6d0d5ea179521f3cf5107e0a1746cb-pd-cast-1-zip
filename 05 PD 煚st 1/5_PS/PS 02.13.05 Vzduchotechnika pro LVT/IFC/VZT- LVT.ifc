Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: ZDE ZADEJTE ČÍSLO PROJEKTU
Time: 2021-05-31T14:48:00
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - IFC Model Exchange with Archicad 24.0.0.4000

# IfcProject, ZDE ZADEJTE ČÍSLO PROJEKTU
LongName: ZDE ZADEJTE NÁZEV PROJEKTU; Phase: ZDE ZADEJTE STUPEŇ PD

# IfcSite, Default
RefLatitude: 50, 4, 59, 999999; RefLongitude: 14, 24, 59, 999999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey (2)
Name | LongName | Elevation (mm)
1NP | 1NP | 0
Střecha | Střecha | 14900

# IfcBuildingStorey: Podlaží:Podlaží (3)
Name | LongName | Elevation (mm)
2.NP | 2.NP | 3800
3.NP | 3.NP | 7600
4.NP | 4.NP | 11250

# IfcCovering: Izolace potrubí:Tepelná izolace 40mm (26)
In: 3.NP
PredefinedType: INSULATION; Material: Tepelná izolace 40mm
Pset_CoveringCommon - Reference: Tepelná izolace 40mm; sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Izolace potrubí:Tepelná izolace 40mm:...)
4238081
4238082
4238083
4238084
4238085
4238086
4238089
4238110
4238111
4238112
4238113
4238114
4238115
4238116
4238119
4238121
4239033
4244177
4244178
4244242
4244271
4244294
4244881
4244882
4244901
4244902

# IfcCovering: Izolace potrubí:Tepelná izolace kaučuk 20mm (30)
In: 3.NP
PredefinedType: INSULATION; Material: Tepelná izolace kaučuk 20mm
Pset_CoveringCommon - Reference: Tepelná izolace kaučuk 20mm; sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Izolace potrubí:Tepelná izolace kaučuk 20mm:...)
4231092
4231093
4231094
4231095
4231096
4231097
4231098
4231099
4231100
4231101
4231102
4231103
4231104
4231105
4231323
4233888
4233889
4233890
4233891
4233892
4233893
4233894
4233895
4233896
4233897
4233899
4233900
4233901
4233902
4239028

# IfcDistributionPort (236)
Name | Description | FlowDirection | Group | Pset_DistributionPortDuct, PortNumber | Pset_DistributionPortDuct, ConnectionType | MEPPortDuct, ProfileShape | MEPPortDuct, NominalWidth (mm) | MEPPortDuct, NominalHeight (mm)
InPort_4224730 | Flow | SOURCEANDSINK | Venkovní vzduch 15
OutPort_4225274 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 550 | 550
InPort_4224730 | Flow | SOURCEANDSINK | Odváděný vzduch 5
OutPort_4225740 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 550 | 550
InPort_4229169 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 550 | 550
OutPort_4224730 | Flow | SOURCE | Odpadní vzduch 13
InPort_4224730 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
OutPort_4225999 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 550 | 550
InPort_4225274 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 550 | 550
OutPort_4225297 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 550 | 550
InPort_4225297 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 200 | 550
OutPort_4225316 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 200 | 550
InPort_4225316 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 200 | 550
OutPort_4225404 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 200 | 550
InPort_4225397 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 550 | 200
OutPort_4225404 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 200 | 550
InPort_4225397 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 550 | 200
OutPort_4228245 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 550 | 200
InPort_4225740 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | RECTANGULAR | 550 | 550
OutPort_4225787 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 550 | 550
InPort_4225754 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 400 | 500
OutPort_4225937 | Flow | SOURCEANDSINK | Odváděný vzduch 5
InPort_4225754 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4232230 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4225787 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4225959 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4225937 | Flow | SOURCEANDSINK | Odváděný vzduch 5
OutPort_4225959 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | RECTANGULAR | 400 | 500
InPort_4225999 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | RECTANGULAR | 550 | 550
OutPort_4226051 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 550 | 550
InPort_4226051 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4229516 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4226169 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 400 | 500
OutPort_4229464 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
InPort_4226169 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4229015 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4227240 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
OutPort_4244401 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
InPort_4227240 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4244243 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4228236 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 500
OutPort_4233034 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4228236 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4228323 | Flow | SOURCEANDSINK | Venkovní vzduch 15
InPort_4228245 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4228337 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4228323 | Flow | SOURCEANDSINK | Venkovní vzduch 15
OutPort_4228337 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 500
InPort_4229008 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 300 | 500
OutPort_4229015 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | RECTANGULAR | 300 | 500
InPort_4229008 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | RECTANGULAR | 300 | 500
OutPort_4244012 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 300 | 500
InPort_4229208 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 550 | 550
OutPort_4229169 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 550 | 550
InPort_4229201 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 550
OutPort_4229208 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 550
InPort_4229786 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 550 | 400
OutPort_4229201 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 550
InPort_4229464 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
OutPort_4229516 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | RECTANGULAR | 400 | 500
InPort_4230574 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 500 | 400
OutPort_4229675 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 500
InPort_4229675 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 500
OutPort_4230331 | Flow | SOURCE | Odpadní vzduch 13
InPort_4230383 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 500
OutPort_4229786 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 500 | 400
InPort_4230331 | Flow | SINK | Odpadní vzduch 13
OutPort_4230383 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 500
InPort_4231060 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
OutPort_4230574 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 200 | 400
InPort_4231036 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 200 | 400
OutPort_4230638 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
InPort_4230638 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
OutPort_4231057 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
InPort_4230689 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
OutPort_4231308 | Flow | SOURCE | Odpadní vzduch 13
InPort_4231154 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 200 | 400
OutPort_4230689 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
InPort_4231307 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
OutPort_4231036 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 200 | 400
InPort_4231057 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
OutPort_4231050 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
InPort_4231050 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
OutPort_4231066 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
InPort_4231066 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
OutPort_4231060 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
InPort_4232884 | Flow | SINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
OutPort_4231147 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 1 | NONE | RECTANGULAR | 400 | 200
InPort_4231147 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
OutPort_4231154 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 200 | 400
InPort_4231308 | Flow | SINK | Odpadní vzduch 13
OutPort_4231307 | Flow | SOURCEANDSINK | Odpadní vzduch 13 | 2 | NONE | RECTANGULAR | 400 | 200
InPort_4231833 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
OutPort_4244238 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4231833 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4231928 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4231928 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4244121 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4232219 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 300 | 500
OutPort_4244270 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 300 | 500
InPort_4232219 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | RECTANGULAR | 300 | 500
OutPort_4232230 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | RECTANGULAR | 300 | 500
InPort_4232320 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
OutPort_4244290 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
InPort_4232320 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
OutPort_4244897 | Flow | SOURCEANDSINK | Odváděný vzduch 5
InPort_4232672 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
OutPort_4244295 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
InPort_4232672 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
OutPort_4244451 | Flow | SOURCEANDSINK | Odváděný vzduch 5
InPort_4233034 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
OutPort_4233560 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 400
InPort_4233560 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
OutPort_4233701 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 400
InPort_4233694 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 400
OutPort_4233710 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 400
InPort_4233694 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
OutPort_4233701 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
InPort_4233704 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 400
OutPort_4233710 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
InPort_4233704 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
2 x OutPort_4233832 | Flow | SOURCEANDSINK | Venkovní vzduch 15
InPort_4233831 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 1 | NONE | RECTANGULAR | 400 | 400
Port_4233831 | Flow | SOURCEANDSINK | Venkovní vzduch 15 | 2 | NONE | RECTANGULAR | 400 | 400
InPort_4234148 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
OutPort_4244295 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
InPort_4234148 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
OutPort_4234627 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
InPort_4235972 | Flow | SINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 625 | 75
OutPort_4234338 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
InPort_4235863 | Flow | SINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 625 | 75
OutPort_4234338 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
InPort_4234338 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 3 | NONE | ROUND | 315 | 315
OutPort_4234760 | Flow | SOURCE | Odváděný vzduch 5
InPort_4236026 | Flow | SINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 625 | 75
OutPort_4234338 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 4 | NONE | ROUND | 315 | 315
InPort_4236111 | Flow | SINK | Odváděný vzduch 5 | 1 | NONE | RECTANGULAR | 625 | 75
OutPort_4234338 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 5 | NONE | ROUND | 315 | 315
InPort_4234338 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 6 | NONE | ROUND | 315 | 315
OutPort_4234627 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
InPort_4234747 | Flow | SINK | Přiváděný vzduch 6
OutPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4234901 | Flow | SOURCE | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 625 | 75
InPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 3 | NONE | ROUND | 315 | 315
OutPort_4234994 | Flow | SOURCE | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 625 | 75
InPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 4 | NONE | ROUND | 315 | 315
OutPort_4235044 | Flow | SOURCE | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 625 | 75
InPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 5 | NONE | ROUND | 315 | 315
OutPort_4235119 | Flow | SOURCE | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 625 | 75
InPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 6 | NONE | ROUND | 315 | 315
OutPort_4244243 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
InPort_4236966 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 7 | NONE | ROUND | 315 | 315
OutPort_4237279 | Flow | SOURCE | Přiváděný vzduch 6 | 1 | NONE | RECTANGULAR | 625 | 75
InPort_4244012 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4244879 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4244121 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4244876 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
InPort_4244238 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
OutPort_4244436 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 1 | NONE | ROUND | 315 | 315
InPort_4244270 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
OutPort_4244899 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
InPort_4244290 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
OutPort_4244472 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 1 | NONE | ROUND | 315 | 315
InPort_4244401 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
OutPort_4244436 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
InPort_4244451 | Flow | SOURCEANDSINK | Odváděný vzduch 5
OutPort_4244472 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
InPort_4244876 | Flow | SOURCEANDSINK | Přiváděný vzduch 6
OutPort_4244879 | Flow | SOURCEANDSINK | Přiváděný vzduch 6 | 2 | NONE | ROUND | 315 | 315
InPort_4244897 | Flow | SOURCEANDSINK | Odváděný vzduch 5
OutPort_4244899 | Flow | SOURCEANDSINK | Odváděný vzduch 5 | 2 | NONE | ROUND | 315 | 315
InPort_4245800 | Flow | SOURCEANDSINK | Přiváděný vzduch 7
OutPort_4245962 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 1080 | 680
InPort_4245962 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 2 | NONE | RECTANGULAR | 1080 | 680
OutPort_4246409 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 1080 | 680
InPort_4246380 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 680 | 600
OutPort_4247634 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246380 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 2 | NONE | RECTANGULAR | 680 | 600
OutPort_4247715 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246380 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 3 | NONE | RECTANGULAR | 680 | 600
OutPort_4247412 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246380 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 4 | NONE | RECTANGULAR | 680 | 600
OutPort_4246409 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 2 | NONE | RECTANGULAR | 600 | 680
InPort_4246380 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 5 | NONE | RECTANGULAR | 680 | 600
OutPort_4247538 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246556 | Flow | SINK | Přiváděný vzduch 7
OutPort_4246380 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 6 | NONE | RECTANGULAR | 680 | 600
InPort_4246409 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 3 | NONE | RECTANGULAR | 600 | 680
OutPort_4246467 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 680 | 600
InPort_4246467 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 2 | NONE | RECTANGULAR | 680 | 600
OutPort_4247308 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246549 | Flow | SINK | Přiváděný vzduch 7
OutPort_4246467 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 3 | NONE | RECTANGULAR | 680 | 600
InPort_4246467 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 4 | NONE | RECTANGULAR | 680 | 600
OutPort_4248452 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246467 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 5 | NONE | RECTANGULAR | 680 | 600
OutPort_4247121 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
InPort_4246467 | Flow | SOURCEANDSINK | Přiváděný vzduch 7 | 6 | NONE | RECTANGULAR | 680 | 600
OutPort_4247038 | Flow | SOURCE | Přiváděný vzduch 7 | 1 | NONE | RECTANGULAR | 525 | 525
 |  | SOURCEANDSINK |  | 1 | NONE | RECTANGULAR | 550 | 550
 |  | SOURCEANDSINK |  | 2 | NONE | RECTANGULAR | 550 | 550
 |  | SOURCEANDSINK |  | 3 | NONE | RECTANGULAR | 550 | 550
 |  | SOURCEANDSINK |  | 4 | NONE | RECTANGULAR | 550 | 550
4 x  |  | SOURCEANDSINK |  | 1 | NONE | RECTANGULAR | 400 | 500
4 x  |  | SOURCEANDSINK |  | 2 | NONE | RECTANGULAR | 400 | 500
 |  | SOURCEANDSINK |  | 1 | NONE | RECTANGULAR | 400 | 200
 |  | SOURCEANDSINK |  | 2 | NONE | RECTANGULAR | 400 | 200
 |  | SOURCEANDSINK |  | 1 | NONE | RECTANGULAR | 400 | 400
 |  | SOURCEANDSINK |  | 2 | NONE | RECTANGULAR | 400 | 400
6 x  |  | SOURCEANDSINK |  | 1 | NONE | ROUND | 315 | 315
 |  | SOURCEANDSINK | Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 25 mm; ConnectorDiameter: 25 mm; NominalWidth: 25 mm; NominalHeight: 25 mm
 |  | SOURCEANDSINK | Pset_DistributionPortPipe - PortNumber: 2; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 8 mm; ConnectorDiameter: 8 mm; NominalWidth: 8 mm; NominalHeight: 8 mm
 |  | SOURCEANDSINK | Pset_DistributionPortPipe - PortNumber: 3; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 20 mm; ConnectorDiameter: 20 mm; NominalWidth: 20 mm; NominalHeight: 20 mm
 |  | SOURCEANDSINK | Pset_DistributionPortPipe - PortNumber: 4; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 8 mm; ConnectorDiameter: 8 mm; NominalWidth: 8 mm; NominalHeight: 8 mm
 |  | SOURCEANDSINK | Pset_DistributionPortPipe - PortNumber: 5; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 40 mm; ConnectorDiameter: 40 mm; NominalWidth: 40 mm; NominalHeight: 40 mm
 |  | SOURCEANDSINK | Pset_DistributionPortPipe - PortNumber: 6; ConnectionType: WELDED; MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 10 mm; ConnectorDiameter: 10 mm; NominalWidth: 10 mm; NominalHeight: 10 mm
4 x  |  | SOURCEANDSINK |  | 2 | NONE | ROUND | 315 | 315
 |  | SOURCEANDSINK |  | 1 | NONE | RECTANGULAR | 1080 | 680
2 x  |  | SOURCEANDSINK |  | 1 | NONE | RECTANGULAR | 680 | 600

# IfcEnergyConversionDevice: Přesná klimatizace:Přesná klimatizace, Přesná klimatizace:Přesná klimatizace:4245800
In: 2.NP
Type - Pset_BuildingElementProxyCommon - Reference: Přesná klimatizace
Type - Pset_QuantityTakeOff - Reference: Přesná klimatizace
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 1940 mm; Height: 780 mm; Depth: 1940 mm
REVIT Klasifikace - OZNAČENÍ: Jednotka VZT; SNIM: JV.01 Samostatná
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: Přiváděný vzduch 7

# IfcEnergyConversionDevice: Zvlhčovač_Condair_RS_velikost_S_EP:Zvlhčovač, Zvlhčovač_Condair_RS_velikost_S_EP:Zvlhčovač:4238455
In: 3.NP
Type - Pset_BuildingElementProxyCommon - Reference: Zvlhčovač
Type - Pset_ManufacturerTypeInformation - Manufacturer: Condair AG
Type - Pset_QuantityTakeOff - Reference: Zvlhčovač
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 420 mm; Height: 670 mm; Depth: 370 mm
REVIT Klasifikace - OZNAČENÍ: Vyvíječ páry; SNIM: YP.
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcEnergyConversionDevice: z.č.5:z.č.5, z.č.5:z.č.5:4224730
In: 3.NP
Type - Pset_BuildingElementProxyCommon - Reference: z.č.5
Type - Pset_QuantityTakeOff - Reference: z.č.5
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 692 mm; Height: 285 mm; Depth: 692 mm
REVIT Klasifikace - OZNAČENÍ: Jednotka VZT; SNIM: JV.01 Samostatná
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: Přiváděný vzduch 6; Odpadní vzduch 13; Odváděný vzduch 5; Venkovní vzduch 15

# IfcFlowController: Hranaté_Spojka_EP:Spojka (2)
In: 3.NP
Type - Pset_DistributionFlowElementCommon - Reference: Spojka
Type - Pset_QuantityTakeOff - Reference: Spojka
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Hranaté_Spojka_EP:Spojka:...) | Group
4231308 | Odpadní vzduch 13
4233832 | Venkovní vzduch 15

# IfcFlowController: Požární klapka_Kruhová_EP:Servopohon (2)
In: 3.NP
Type - Pset_BuildingElementProxyCommon - Reference: Servopohon
Type - Pset_QuantityTakeOff - Reference: Servopohon
Pset_BuildingElementProxyCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Požární klapka_Kruhová_EP:Servopohon:...) | Group
4244451 | Odváděný vzduch 5
4244401 | Přiváděný vzduch 6 | Pset_ProvisionForVoid - Width: 450 mm; Depth: 450 mm

# IfcFlowController: Regulační klapka_Kruhová_EP:Servopohon (2)
In: 3.NP
Type - Pset_BuildingElementProxyCommon - Reference: Servopohon
Type - Pset_QuantityTakeOff - Reference: Servopohon
Pset_BuildingElementProxyCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Klapka; SNIM: KA.02 Uzavírací
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Regulační klapka_Kruhová_EP:Servopohon:...) | Group
4244897 | Odváděný vzduch 5
4244876 | Přiváděný vzduch 6 | Pset_ProvisionForVoid - Width: 315 mm; Depth: 315 mm

# IfcFlowController: Tlumič hluku_Hranatý_EP:Tlumič hluku_Hranatý_EP (4)
In: 3.NP
Type - Pset_BuildingElementProxyCommon - Reference: Tlumič hluku_Hranatý_EP
Type - Pset_QuantityTakeOff - Reference: Tlumič hluku_Hranatý_EP
Pset_BuildingElementProxyCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tlumič; SNIM: TC.02 Akustický
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Tlumič hluku_Hranatý_EP:Tlumič hluku_Hranatý_EP:...) | Width (mm) = Depth (mm) | Height (mm) | Group
4225937 | 560 | 460 | Odváděný vzduch 5
4228323 | 560 | 460 | Venkovní vzduch 15
4229464 | 560 | 460 | Přiváděný vzduch 6
4230331 |  |  | Odpadní vzduch 13

# IfcFlowFitting: Hranaté_Oblouk_EP:R 150 (7)
In: 3.NP
Type - Material: <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: R 150
Type - Pset_QuantityTakeOff - Reference: R 150
Classification: Tvarovka potrubí (Uniformat); TA.02 Oblouk (Default Classification)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.02 Oblouk
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Hranaté_Oblouk_EP:R 150:...) | Group
4225404 | Venkovní vzduch 15
4231036 | Odpadní vzduch 13
4231057 | Odpadní vzduch 13
4231066 | Odpadní vzduch 13
4231154 | Odpadní vzduch 13
4233701 | Venkovní vzduch 15
4233710 | Venkovní vzduch 15

# IfcFlowFitting: Hranaté_Oblouk_Přechodový_EP:R 100 (2)
In: 3.NP
Type - Material: <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: R 100
Type - Pset_QuantityTakeOff - Reference: R 100
Classification: TA.10 Oblouk přechodový (Default Classification); Tvarovka potrubí (Uniformat); Group: Odpadní vzduch 13
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.10 Oblouk přechodový
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Hranaté_Oblouk_Přechodový_EP:R 100:...)
4229208
4229786

# IfcFlowFitting: Hranaté_Oblouk_Přechodový_EP:R 150 (4)
In: 3.NP
Type - Material: <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: R 150
Type - Pset_QuantityTakeOff - Reference: R 150
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Hranaté_Oblouk_Přechodový_EP:R 150:...) | Classification | SNIM | Group
4225297 | TA.10 Oblouk přechodový (Default Classification); Tvarovka potrubí (Uniformat) | TA.10 Oblouk přechodový | Venkovní vzduch 15
4229015 | Tvarovka potrubí (Uniformat); TA.02 Oblouk (Default Classification) | TA.02 Oblouk | Přiváděný vzduch 6
4230574 | TA.10 Oblouk přechodový (Default Classification); Tvarovka potrubí (Uniformat) | TA.10 Oblouk přechodový | Odpadní vzduch 13
4232230 | Tvarovka potrubí (Uniformat); TA.02 Oblouk (Default Classification) | TA.02 Oblouk | Odváděný vzduch 5

# IfcFlowFitting: Hranaté_Odbočka_EP:R 150, Hranaté_Odbočka_EP:R 150:4246409
In: 2.NP
Type - Pset_DistributionFlowElementCommon - Reference: R 150
Type - Pset_QuantityTakeOff - Reference: R 150
Classification: Tvarovka potrubí (Uniformat); TA.04 Odbočka (Default Classification); Group: Přiváděný vzduch 7
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.04 Odbočka
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcFlowFitting: Hranaté_Přechod tvaru symetrický_EP:L 500, Hranaté_Přechod tvaru symetrický_EP:L 500:4244270
In: 3.NP
Type - Pset_DistributionFlowElementCommon - Reference: L 500
Type - Pset_ManufacturerTypeInformation - Manufacturer: The information, formulas, and/or data contained in this Revit family API/APIAGRA is copyrighted by Company APIAGRA s.r.o.® and may not be modified, reproduced in whole or in part without the prior, handwritten and signed consent of Director Company APIA
Type - Pset_QuantityTakeOff - Reference: L 500
Classification: Tvarovka potrubí (Uniformat); TA.03 Přechod (Default Classification); Group: Odváděný vzduch 5
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.03 Přechod
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcFlowFitting: Hranaté_Přechod tvaru_nesymetrický_EP:L 500, Hranaté_Přechod tvaru_nesymetrický_EP:L 500:4244012
In: 3.NP
Type - Pset_DistributionFlowElementCommon - Reference: L 500
Type - Pset_ManufacturerTypeInformation - Manufacturer: The information, formulas, and/or data contained in this Revit family API/APIAGRA is copyrighted by Company APIAGRA s.r.o.® and may not be modified, reproduced in whole or in part without the prior, handwritten and signed consent of Director Company APIA
Type - Pset_QuantityTakeOff - Reference: L 500
Classification: Tvarovka potrubí (Uniformat); TA.03 Přechod (Default Classification); Group: Přiváděný vzduch 6
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.03 Přechod
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcFlowFitting: Hranaté_Přechod_hranatý_EP:L 250 (3)
In: 3.NP
Type - Classification: Čtyřhranné potrubí skupiny I. (Uniformat)
Type - Pset_DistributionFlowElementCommon - Reference: L 250
Type - Pset_ManufacturerTypeInformation - Manufacturer: The information, formulas, and/or data contained in this Revit family API/APIAGRA is copyrighted by Company APIAGRA s.r.o.® and may not be modified, reproduced in whole or in part without the prior, handwritten and signed consent of Director Company APIA
Type - Pset_QuantityTakeOff - Reference: L 250
Classification: Čtyřhranné potrubí skupiny I. (Uniformat); TA.03 Přechod (Default Classification)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.03 Přechod
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Hranaté_Přechod_hranatý_EP:L 250:...) | Group
4225787 | Odváděný vzduch 5
4226051 | Přiváděný vzduch 6
4233034 | Venkovní vzduch 15

# IfcFlowFitting: Hranaté_Přechod_hranatý_EP:L 500, Hranaté_Přechod_hranatý_EP:L 500:4228245
In: 3.NP
Type - Classification: Čtyřhranné potrubí skupiny I. (Uniformat)
Type - Pset_DistributionFlowElementCommon - Reference: L 500
Type - Pset_ManufacturerTypeInformation - Manufacturer: The information, formulas, and/or data contained in this Revit family API/APIAGRA is copyrighted by Company APIAGRA s.r.o.® and may not be modified, reproduced in whole or in part without the prior, handwritten and signed consent of Director Company APIA
Type - Pset_QuantityTakeOff - Reference: L 500
Classification: Čtyřhranné potrubí skupiny I. (Uniformat); TA.03 Přechod (Default Classification); Group: Venkovní vzduch 15
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.03 Přechod
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcFlowFitting: Kruhové_Oblouk_EP:1 D (6)
Type - Material: <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: 1 D
Type - Pset_QuantityTakeOff - Reference: 1 D
Classification: Tvarovka potrubí (Uniformat); TA.02 Oblouk (Default Classification)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.02 Oblouk
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Kruhové_Oblouk_EP:1 D:...) | In | Group
4231928 | 3.NP | Přiváděný vzduch 6
4234627 | 3.NP | Odváděný vzduch 5
4244238 | 3.NP | Přiváděný vzduch 6
4244243 | 2.NP | Přiváděný vzduch 6
4244290 | 3.NP | Odváděný vzduch 5
4244295 | 3.NP | Odváděný vzduch 5

# IfcFlowSegment: Nástavec (12)
Type - ElementType: Nástavec; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: ROUND; NominalDiameterOrWidth: 315; NominalHeight: 315
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Nástavec; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Kulaté potrubí:Nástavec:...) | In | Length (mm) | Group
4227240 | 3.NP | 259.988 | Přiváděný vzduch 6
4231833 | 3.NP | 319.202 | Přiváděný vzduch 6
4232320 | 3.NP | 1106.54 | Odváděný vzduch 5
4232672 | 3.NP | 609.885 | Odváděný vzduch 5
4234148 | 3.NP | 323.17 | Odváděný vzduch 5
4234338 | 2.NP | 5350.2 | Odváděný vzduch 5
4236966 | 2.NP | 6396.07 | Přiváděný vzduch 6
4244121 | 3.NP | 189.704 | Přiváděný vzduch 6
4244436 | 3.NP | 143.512 | Přiváděný vzduch 6
4244472 | 3.NP | 683.115 | Odváděný vzduch 5
4244879 | 3.NP | 235.456 | Přiváděný vzduch 6
4244899 | 3.NP | 160.456 | Odváděný vzduch 5

# IfcFlowSegment: Nástavec_oblouk normal, Hranaté potrubí:Nástavec_oblouk normal:4245962
In: 2.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 1080; NominalHeight: 680
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Přiváděný vzduch 7
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentDuctSegment - Length: 198.099 mm

# IfcFlowSegment: Nástavec_oblouk normal, Hranaté potrubí:Nástavec_oblouk normal:4225316
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 200; NominalHeight: 550
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Venkovní vzduch 15
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentDuctSegment - Length: 42 mm

# IfcFlowSegment: Nástavec_oblouk normal (2)
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 300; NominalHeight: 500
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Hranaté potrubí:Nástavec_oblouk normal:...) | Length (mm) | Group
4229008 | 3 | Přiváděný vzduch 6
4232219 | 78 | Odváděný vzduch 5

# IfcFlowSegment: Nástavec_oblouk normal (6)
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 400; NominalHeight: 200
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Odpadní vzduch 13
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Hranaté potrubí:Nástavec_oblouk normal:...) | In | Length (mm)
4230638 | 3.NP | 3.01778
4230689 | 3.NP | 1120
4231050 | 3.NP | 10.476
4231060 | 3.NP | 792.909
4231147 | 4.NP | 200
4231307 | 3.NP | 463

# IfcFlowSegment: Nástavec_oblouk normal (4)
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 400; NominalHeight: 400
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Venkovní vzduch 15
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Hranaté potrubí:Nástavec_oblouk normal:...) | Length (mm)
4233560 | 4378.13
4233694 | 695.836
4233704 | 50
4233831 | 425.04

# IfcFlowSegment: Nástavec_oblouk normal (8)
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 400; NominalHeight: 500
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Hranaté potrubí:Nástavec_oblouk normal:...) | Length (mm) | Group
4225754 | 1500.38 | Odváděný vzduch 5
4225959 | 53.2534 | Odváděný vzduch 5
4226169 | 3.00524 | Přiváděný vzduch 6
4228236 | 3.85978 | Venkovní vzduch 15
4228337 | 180.836 | Venkovní vzduch 15
4229516 | 2.99476 | Přiváděný vzduch 6
4229675 | 3 | Odpadní vzduch 13
4230383 | 53 | Odpadní vzduch 13

# IfcFlowSegment: Nástavec_oblouk normal, Hranaté potrubí:Nástavec_oblouk normal:4229201
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 400; NominalHeight: 550
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Odpadní vzduch 13
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentDuctSegment - Length: 3 mm

# IfcFlowSegment: Nástavec_oblouk normal, Hranaté potrubí:Nástavec_oblouk normal:4225397
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 550; NominalHeight: 200
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Venkovní vzduch 15
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentDuctSegment - Length: 3.30432 mm

# IfcFlowSegment: Nástavec_oblouk normal (4)
In: 3.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 550; NominalHeight: 550
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Hranaté potrubí:Nástavec_oblouk normal:...) | Length (mm) | Group
4225274 | 5 | Venkovní vzduch 15
4225740 | 3.80367 | Odváděný vzduch 5
4225999 | 2.80367 | Přiváděný vzduch 6
4229169 | 90 | Odpadní vzduch 13

# IfcFlowSegment: Nástavec_oblouk normal (2)
In: 2.NP
Type - ElementType: Nástavec_oblouk normal; PredefinedType: RIGIDSEGMENT
Type - Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR; NominalDiameterOrWidth: 680; NominalHeight: 600
Classification: PO.02 Pozinkované (Default Classification); Potrubí (Uniformat); Group: Přiváděný vzduch 7
Pset_DistributionFlowElementCommon - Reference: Nástavec_oblouk normal; sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Potrubí; SNIM: PO.02 Pozinkované
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Hranaté potrubí:Nástavec_oblouk normal:...) | Length (mm)
4246380 | 2652.98
4246467 | 2640

# IfcFlowTerminal: Hranaté_Uzavření_EP:Uzavření (2)
In: 2.NP
Type - Pset_DistributionFlowElementCommon - Reference: Uzavření
Type - Pset_QuantityTakeOff - Reference: Uzavření
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.07 Uzavření
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: Přiváděný vzduch 7
Name (Hranaté_Uzavření_EP:Uzavření:...)
4246549
4246556

# IfcFlowTerminal: Kruhové_Uzavření_EP:Uzavření (2)
In: 2.NP
Type - Pset_DistributionFlowElementCommon - Reference: Uzavření
Type - Pset_QuantityTakeOff - Reference: Uzavření
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tvarovka potrubí; SNIM: TA.07 Uzavření
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Kruhové_Uzavření_EP:Uzavření:...) | Group
4234747 | Přiváděný vzduch 6
4234760 | Odváděný vzduch 5

# IfcFlowTerminal: Vyústka do čtyřhranného potrubí_instance_odvodní_EP:Vyústka do čtyřhranného potrubí_instance_odvodní_EP (4)
In: 2.NP
Type - Pset_DistributionFlowElementCommon - Reference: Vyústka do čtyřhranného potrubí_instance_odvodní_EP
Type - Pset_QuantityTakeOff - Reference: Vyústka do čtyřhranného potrubí_instance_odvodní_EP
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: Odváděný vzduch 5
Name (Vyústka do čtyřhranného potrubí_instance_odvodní_EP:Vyústka do čtyřhranného potrubí_instance_odvodní_EP:...)
4235863
4235972
4236026
4236111

# IfcFlowTerminal: Vyústka do čtyřhranného potrubí_instance_přívodní_EP:Vyústka do čtyřhranného potrubí_instance_přívodní_EP (13)
In: 2.NP
Type - Pset_DistributionFlowElementCommon - Reference: Vyústka do čtyřhranného potrubí_instance_přívodní_EP
Type - Pset_QuantityTakeOff - Reference: Vyústka do čtyřhranného potrubí_instance_přívodní_EP
Classification: VV.01 Vyústka (Default Classification); Vyústka (Uniformat)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Vyústka; SNIM: VV.01 Vyústka
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Vyústka do čtyřhranného potrubí_instance_přívodní_EP:Vyústka do čtyřhranného potrubí_instance_přívodní_EP:...) | Group
4234901 | Přiváděný vzduch 6
4234994 | Přiváděný vzduch 6
4235044 | Přiváděný vzduch 6
4235119 | Přiváděný vzduch 6
4237279 | Přiváděný vzduch 6
4247038 | Přiváděný vzduch 7
4247121 | Přiváděný vzduch 7
4247308 | Přiváděný vzduch 7
4247412 | Přiváděný vzduch 7
4247538 | Přiváděný vzduch 7
4247634 | Přiváděný vzduch 7
4247715 | Přiváděný vzduch 7
4248452 | Přiváděný vzduch 7

# IfcFlowTerminal: Šikmý nástavec_Výfuk_Hranatý_EP:Šikmý nástavec_Výfuk_Hranatý_EP, Šikmý nástavec_Výfuk_Hranatý_EP:Šikmý nástavec_Výfuk_Hranatý_EP:4232884
In: 4.NP
Type - Material: <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: Šikmý nástavec_Výfuk_Hranatý_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Šikmý nástavec_Výfuk_Hranatý_EP
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: Odpadní vzduch 13

# IfcBuildingElementProxyType, no part of this type: Požární klapka_Kruhová_EP:Servopohon
Material: <Unnamed>

# IfcBuildingElementProxyType, no part of this type: Tlumič hluku_Hranatý_EP:Tlumič hluku_Hranatý_EP
Material: <Unnamed>

# IfcBuildingElementProxyType, no part of this type: Tlumič hluku_Hranatý_EP:Tlumič hluku_Hranatý_EP
Material: <Unnamed>

# IfcBuildingElementProxyType, no part of this type: Tlumič hluku_Hranatý_EP:Tlumič hluku_Hranatý_EP
Material: <Unnamed>

# IfcBuildingElementProxyType, no part of this type: Zvlhčovač_Condair_RS_velikost_S_EP:Zvlhčovač
Material: Stainless Steel - Condair - Silver, Plastic - Condair - Blue

# IfcDuctFittingType, no part of this type: Hranaté_Spojka_EP:Spojka
Material: <Unnamed>

# IfcDuctFittingType, no part of this type: Hranaté_Spojka_EP:Spojka
Material: <Unnamed>

# IfcDuctFittingType, no part of this type: Hranaté_Uzavření_EP:Uzavření
Material: <Unnamed>

# IfcDuctFittingType, no part of this type: Kruhové_Uzavření_EP:Uzavření
Material: <Unnamed>
