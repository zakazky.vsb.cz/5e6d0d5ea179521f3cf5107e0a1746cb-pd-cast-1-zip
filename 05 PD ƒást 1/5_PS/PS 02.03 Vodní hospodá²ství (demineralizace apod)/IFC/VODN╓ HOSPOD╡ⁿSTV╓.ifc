Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: ZDE ZADEJTE ČÍSLO PROJEKTU
Time: 2021-05-31T08:54:37
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 21.1.11.27 - Exporter 21.1.11.27 - IFC Model Exchange with Archicad 24.0.0.4000

# IfcProject, ZDE ZADEJTE ČÍSLO PROJEKTU
LongName: ZDE ZADEJTE NÁZEV PROJEKTU; Phase: ZDE ZADEJTE STUPEŇ PD

# IfcSite, Default
RefLatitude: 50, 4, 59, 999999; RefLongitude: 14, 24, 59, 999999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 5

# IfcBuildingStorey (4)
Name | LongName | Elevation (mm)
1NP | 1NP | 0
4.NP | 4.NP | 11250
5.NP | 5.NP | 14900
ZÁKLADY | ZÁKLADY | -3000

# IfcBuildingStorey: Podlaží:Podlaží (4)
Name | LongName | Elevation (mm)
NEHMOTNÉ POLOŽKY | NEHMOTNÉ POLOŽKY | -7000
1.NP | 1.NP | -1.79661e-14
2.NP | 2.NP | 3800
3.NP | 3.NP | 7600

# IfcBuildingElementProxy: Elektrický rozvaděč k UV lampě UVH2_EP:Elektrický rozvaděč k UV lampě UVH2_EP, Elektrický rozvaděč k UV lampě UVH2_EP:Elektrický rozvaděč k UV lampě UVH2_EP:2017293
In: 1.NP
Type - Pset_BuildingElementProxyCommon - Reference: Elektrický rozvaděč k UV lampě UVH2_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Elektrický rozvaděč k UV lampě UVH2_EP
Pset_BuildingElementProxyCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Zasobnik_EP:Zasobnik_EP (2)
In: 1.NP
Type - Material: Smooth - Off-White
Type - Pset_BuildingElementProxyCommon - Reference: Zasobnik_EP
Type - Pset_QuantityTakeOff - Reference: Zasobnik_EP
Classification: ZN.01 Stojatý (Default Classification); Zásobník (Uniformat); Material: Semi-Polished, Default, Smooth - Off-White
Pset_BuildingElementProxyCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Zásobník; SNIM: ZN.01 Stojatý
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Zasobnik_EP:Zasobnik_EP:...)
1933966 | Pset_ProvisionForVoid - Width: 2 mm; Depth: 2 mm
1934114

# IfcDistributionPort (714)
Name | Description | FlowDirection | Group | PortNumber | ConnectionType | ProfileShape | OuterDiameter (mm) | ConnectorDiameter (mm) = NominalWidth (mm) = NominalHeight (mm)
InPort_2007582 | Flow | SOURCEANDSINK | nový 117
OutPort_2010472 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
2 x InPort_2009466 | Flow | SOURCEANDSINK | nový 117
OutPort_2011353 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2010725 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2009723 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2011351 | Flow | SOURCEANDSINK | nový 117
InPort_2009723 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2011704 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2009975 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2011704 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2009975 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010403 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010007 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2009983 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2009983 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010403 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2010005 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 40 | 40
OutPort_2009993 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2009993 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010007 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2010022 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2012350 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010022 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010829 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010403 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2010423 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010423 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010445 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010436 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2010445 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2010436 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010470 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010462 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2010482 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010462 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010470 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2010472 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010482 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
2 x InPort_2010713 | Flow | SOURCEANDSINK | nový 117
OutPort_2012351 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2010725 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2010821 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2010837 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010821 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2010829 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2010837 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2012732 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2010841 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2015361 | Flow | SOURCEANDSINK | nový 117
InPort_2010841 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2014241 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2011351 | Flow | SOURCEANDSINK | nový 117
OutPort_2011353 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2011704 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2012097 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012097 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2012118 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012110 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2012191 | Flow | SOURCEANDSINK | nový 117
InPort_2012110 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2012354 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012118 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2012212 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012132 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2012350 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2012132 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2012354 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2012191 | Flow | SOURCEANDSINK | nový 117
OutPort_2012212 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2012350 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2012351 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2012369 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 18 | 15
OutPort_2012644 | Flow | SOURCEANDSINK | nový 117
InPort_2012369 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 18 | 15
OutPort_2012731 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012387 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2015044 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012387 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2014180 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
Port_2012644 | Flow | SOURCEANDSINK | nový 117
InPort_2012731 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2015045 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2012731 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 18 | 15
OutPort_2012732 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2014178 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2014180 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2014178 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2014182 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014182 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2015374 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014233 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2014264 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014233 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2014241 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
Port_2014258 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014258 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2014264 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2014288 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2014771 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
Port_2014288 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2014771 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2014886 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
2 x InPort_2014864 | Flow | SOURCEANDSINK | nový 117
OutPort_2014886 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2016391 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014978 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2016390 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014978 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2016388 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014991 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2015048 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2014991 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2015162 | Flow | SOURCEANDSINK | nový 117
InPort_2015032 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2015044 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2015032 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2015048 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2015044 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2015045 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2015162 | Flow | SOURCEANDSINK | nový 117
OutPort_2015197 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2015197 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2016388 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2015361 | Flow | SOURCEANDSINK | nový 117
OutPort_2015374 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
2 x InPort_2015882 | Flow | SOURCEANDSINK | nový 117
OutPort_2017571 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 22 | 20
OutPort_2017026 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2016383 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2018201 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2016383 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2016390 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2016390 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2016391 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2016614 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2018201 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2016614 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2017022 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2016913 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2017026 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 20 | 20
InPort_2016913 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2017874 | Flow | SOURCEANDSINK | nový 117
InPort_2017022 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2017897 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2017571 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 22 | 20
OutPort_2017642 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 22 | 20
InPort_2017636 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 22 | 20
OutPort_2017642 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 22 | 20
InPort_2017636 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 22 | 20
OutPort_2017709 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 22 | 20
InPort_2017646 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2018296 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2017646 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2019931 | Flow | SOURCEANDSINK | nový 117
InPort_2017709 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2018028 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2017874 | Flow | SOURCEANDSINK | nový 117
OutPort_2017897 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
2 x InPort_2018011 | Flow | SOURCEANDSINK | nový 117
OutPort_2018028 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2018297 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2018201 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2018275 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2018275 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2018304 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2018283 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2018304 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2018283 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2018357 | Flow | SOURCEANDSINK | nový 117
InPort_2018294 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2018300 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2018294 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2018296 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2018296 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 28 | 25
OutPort_2018297 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2018300 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2018359 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2018357 | Flow | SOURCEANDSINK | nový 117
OutPort_2018359 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2018698 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020123 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2018698 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031815 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2019931 | Flow | SOURCEANDSINK | nový 117
OutPort_2020068 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020068 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020108 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020108 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031816 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020113 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020135 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020113 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020123 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020127 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020177 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020127 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020135 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020171 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023445 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020171 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020177 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020255 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020271 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020255 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023445 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020271 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020298 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020298 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020316 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020308 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020796 | Flow | SOURCEANDSINK | nový 117
InPort_2020308 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020544 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020316 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020798 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020344 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020544 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020344 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020548 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 20 | 20
InPort_2020356 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023120 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
InPort_2020356 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023016 | Flow | SOURCEANDSINK | nový 117
2 x InPort_2020448 | Flow | SOURCEANDSINK | nový 117
OutPort_2020588 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2020548 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020557 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023120 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2020557 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
OutPort_2020588 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 20 | 20
InPort_2020796 | Flow | SOURCEANDSINK | nový 117
OutPort_2020798 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2023016 | Flow | SOURCEANDSINK | nový 117
OutPort_2023127 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 28 | 25
Port_2023127 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2023282 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023291 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2023282 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023299 | Flow | SOURCEANDSINK | nový 63
InPort_2023286 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023291 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2023286 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023293 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 20 | 20
InPort_2023288 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023303 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2023288 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023302 | Flow | SOURCEANDSINK | nový 63
2 x InPort_2023290 | Flow | SOURCEANDSINK | nový 63
OutPort_2023297 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023293 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2023295 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023303 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2023295 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023297 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 20 | 20
InPort_2023299 | Flow | SOURCEANDSINK | nový 63
OutPort_2023300 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2023300 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023504 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2023302 | Flow | SOURCEANDSINK | nový 63
OutPort_2023305 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
Port_2023305 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2023496 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023591 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2023496 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023504 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2023577 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023593 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2023577 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2023591 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
2 x InPort_2023793 | Flow | SOURCEANDSINK | nový 63
OutPort_2023941 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
OutPort_2024036 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2023941 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
OutPort_2023999 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2023950 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2023999 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2023950 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2024147 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2024036 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
OutPort_2024056 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2024056 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
OutPort_2031026 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2024147 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2024442 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2024151 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2024440 | Flow | SOURCEANDSINK | nový 63
InPort_2024151 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2030303 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2024305 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2030307 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 20 | 20
InPort_2024305 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2030303 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
Port_2024311 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2024311 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2030335 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2024440 | Flow | SOURCEANDSINK | nový 63
OutPort_2024442 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
2 x InPort_2024660 | Flow | SOURCEANDSINK | nový 63
OutPort_2050730 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
OutPort_2024671 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2024671 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
OutPort_2031007 | Flow | SOURCEANDSINK | nový 63
InPort_2024757 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
OutPort_2050729 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2024757 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
OutPort_2024775 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2024765 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
OutPort_2025143 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
InPort_2024765 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
OutPort_2024775 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
InPort_2025081 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 42 | 40
OutPort_2025143 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
InPort_2025216 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2025215 | Flow | SOURCE | nový 103
InPort_2025215 | Flow | SINK | nový 103
OutPort_2025222 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2025220 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2025216 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2025218 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025220 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2025226 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025218 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2025222 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2025224 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2025224 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2030939 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2025235 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025226 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2025228 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025234 | Flow | SOURCE | nový 103
InPort_2025230 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025228 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2031161 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025230 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2031129 | Flow | SOURCEANDSINK | nový 146 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025232 | Flow | SOURCEANDSINK | nový 146 | 1 | WELDED | ROUND | 28 | 25
InPort_2025232 | Flow | SOURCEANDSINK | nový 146 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031265 | Flow | SOURCE | nový 146
InPort_2025234 | Flow | SINK | nový 103
OutPort_2025235 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2025237 | Flow | SINK | nový 103
OutPort_2025937 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2025238 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2025237 | Flow | SOURCE | nový 103
InPort_2030905 | Flow | SINK | nový 103
OutPort_2025238 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2031127 | Flow | SOURCEANDSINK | nový 146 | 1 | WELDED | ROUND | 28 | 25
OutPort_2025645 | Flow | SOURCEANDSINK | nový 146 | 1 | WELDED | ROUND | 28 | 25
Port_2025645 | Flow | SOURCEANDSINK | nový 146 | 2 | WELDED | ROUND | 28 | 25
InPort_2025937 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2025951 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2025951 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2026086 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2026086 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2026100 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2026100 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028618 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
2 x InPort_2026338 | Flow | SOURCEANDSINK | nový 103
OutPort_2027579 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2026452 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2026452 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2027436 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2026466 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2026486 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2026466 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2027436 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2026476 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2026486 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2026476 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2027128 | Flow | SOURCEANDSINK | nový 103
InPort_2027128 | Flow | SOURCEANDSINK | nový 103
OutPort_2027130 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2027130 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028617 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2027579 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2027603 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2027603 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2027642 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
2 x InPort_2027640 | Flow | SOURCEANDSINK | nový 103
OutPort_2039989 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2027642 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2028427 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2028433 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028427 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028468 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028433 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028892 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028433 | Flow | SOURCEANDSINK | nový 103 | 3 | WELDED | ROUND | 42 | 40
OutPort_2028434 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028434 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2039988 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028460 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2028714 | Flow | SOURCEANDSINK | nový 103
InPort_2028460 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028621 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028468 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028737 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028586 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2028621 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2028586 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028617 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2028618 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028617 | Flow | SOURCEANDSINK | nový 103 | 3 | WELDED | ROUND | 42 | 40
InPort_2028714 | Flow | SOURCEANDSINK | nový 103
OutPort_2028737 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2028892 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028906 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028900 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2028906 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2028900 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2028925 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
InPort_2028910 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 42 | 40
OutPort_2028925 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2029362 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029366 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029362 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031470 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029364 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029373 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029364 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029381 | Flow | SOURCEANDSINK | nový 102
InPort_2029366 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029382 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029368 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029375 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 20 | 20
InPort_2029368 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029373 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029370 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029384 | Flow | SOURCEANDSINK | nový 102
InPort_2029370 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029385 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
2 x InPort_2029372 | Flow | SOURCEANDSINK | nový 102
OutPort_2029379 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029375 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029377 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029379 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 20 | 20
InPort_2029377 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029385 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029381 | Flow | SOURCEANDSINK | nový 102
OutPort_2029382 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029384 | Flow | SOURCEANDSINK | nový 102
OutPort_2029387 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
Port_2029387 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029431 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2031511 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029431 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029435 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029433 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029450 | Flow | SOURCEANDSINK | nový 102
InPort_2029433 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029442 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029435 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029451 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029437 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029442 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029437 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029444 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 20 | 20
InPort_2029439 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029453 | Flow | SOURCEANDSINK | nový 102
InPort_2029439 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029454 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
2 x InPort_2029441 | Flow | SOURCEANDSINK | nový 102
OutPort_2029444 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029448 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2029446 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2029448 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 20 | 20
InPort_2029446 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2029454 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029450 | Flow | SOURCEANDSINK | nový 102
OutPort_2029451 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2029453 | Flow | SOURCEANDSINK | nový 102
OutPort_2029456 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
Port_2029456 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
2 x InPort_2030215 | Flow | SOURCEANDSINK | nový 63
OutPort_2030307 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2030333 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2030319 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
OutPort_2030364 | Flow | SOURCEANDSINK | nový 63
InPort_2030319 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
OutPort_2030335 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2030333 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 20 | 20
OutPort_2030366 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 28 | 25
InPort_2030364 | Flow | SOURCEANDSINK | nový 63
OutPort_2030366 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 28 | 25
InPort_2030939 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
OutPort_2030905 | Flow | SOURCE | nový 103
InPort_2031007 | Flow | SOURCEANDSINK | nový 63
OutPort_2031026 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
2 x InPort_2031087 | Flow | SINK | nový 144
OutPort_2031173 | Flow | SOURCEANDSINK | nový 144 | 1 | WELDED | ROUND | 20 | 20
OutPort_2031129 | Flow | SOURCEANDSINK | nový 144 | 2 | WELDED | ROUND | 20 | 20
InPort_2031300 | Flow | SOURCEANDSINK | nový 146 | 1 | WELDED | ROUND | 28 | 25
OutPort_2031127 | Flow | SOURCEANDSINK | nový 146 | 2 | WELDED | ROUND | 28 | 25
InPort_2031173 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031161 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 28 | 25
InPort_2031265 | Flow | SINK | nový 146
OutPort_2031300 | Flow | SOURCEANDSINK | nový 146 | 2 | WELDED | ROUND | 28 | 25
InPort_2031458 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2031480 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2031458 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031470 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2031480 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031508 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2031493 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
OutPort_2031507 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2031493 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2031511 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2031507 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2051061 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2031507 | Flow | SOURCEANDSINK | nový 102 | 3 | WELDED | ROUND | 28 | 25
OutPort_2031508 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2031582 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 35 | 32
OutPort_2031616 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2031616 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 35 | 32
OutPort_2051043 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2031800 | Flow | SOURCEANDSINK | nový 117 | 1 | WELDED | ROUND | 18 | 15
OutPort_2031815 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
InPort_2031800 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 18 | 15
OutPort_2031972 | Flow | SOURCEANDSINK | nový 117
InPort_2031815 | Flow | SOURCEANDSINK | nový 117 | 3 | WELDED | ROUND | 18 | 15
OutPort_2031816 | Flow | SOURCEANDSINK | nový 117 | 2 | WELDED | ROUND | 28 | 25
Port_2031972 | Flow | SOURCEANDSINK | nový 117
InPort_2032332 | Flow | SOURCEANDSINK | nový 79 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032336 | Flow | SOURCEANDSINK | nový 79 | 1 | WELDED | ROUND | 110 | 110
InPort_2032336 | Flow | SOURCEANDSINK | nový 79 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032356 | Flow | SOURCEANDSINK | nový 79 | 1 | WELDED | ROUND | 110 | 110
InPort_2032350 | Flow | SOURCEANDSINK | nový 79 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032369 | Flow | SOURCEANDSINK | nový 79 | 1 | WELDED | ROUND | 110 | 110
InPort_2032350 | Flow | SOURCEANDSINK | nový 79 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032356 | Flow | SOURCEANDSINK | nový 79 | 2 | WELDED | ROUND | 110 | 110
InPort_2032360 | Flow | SOURCEANDSINK | nový 79 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032369 | Flow | SOURCEANDSINK | nový 79 | 2 | WELDED | ROUND | 110 | 110
Port_2032360 | Flow | SOURCEANDSINK | nový 79 | 2 | WELDED | ROUND | 110 | 110
InPort_2032410 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032449 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
Port_2032410 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032449 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032756 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032550 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032755 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032550 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032784 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032587 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032760 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
Port_2032587 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032740 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032755 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032740 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032760 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032755 | Flow | SOURCEANDSINK | nový 15 | 3 | WELDED | ROUND | 110 | 110
OutPort_2032756 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032776 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032886 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032776 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032784 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032875 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2032898 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032875 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032886 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2032898 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032902 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032902 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032931 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032931 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2032933 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032933 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
OutPort_2033034 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
InPort_2032999 | Flow | SOURCEANDSINK | nový 15 | 1 | WELDED | ROUND | 110 | 110
OutPort_2033034 | Flow | SOURCEANDSINK | nový 15 | 2 | WELDED | ROUND | 110 | 110
InPort_2039944 | Flow | SOURCEANDSINK | nový 103 | 1 | WELDED | ROUND | 22 | 20
OutPort_2039988 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
InPort_2039944 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 22 | 20
OutPort_2040033 | Flow | SOURCEANDSINK | nový 103
InPort_2039988 | Flow | SOURCEANDSINK | nový 103 | 3 | WELDED | ROUND | 22 | 20
OutPort_2039989 | Flow | SOURCEANDSINK | nový 103 | 2 | WELDED | ROUND | 42 | 40
Port_2040033 | Flow | SOURCEANDSINK | nový 103
InPort_2050174 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 18 | 15
OutPort_2050478 | Flow | SOURCEANDSINK | nový 63
InPort_2050174 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 18 | 15
OutPort_2050724 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 22 | 20
Port_2050478 | Flow | SOURCEANDSINK | nový 63
InPort_2050710 | Flow | SOURCEANDSINK | nový 63 | 1 | WELDED | ROUND | 22 | 20
OutPort_2050729 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
InPort_2050710 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 22 | 20
OutPort_2050724 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 18 | 15
InPort_2050729 | Flow | SOURCEANDSINK | nový 63 | 3 | WELDED | ROUND | 22 | 20
OutPort_2050730 | Flow | SOURCEANDSINK | nový 63 | 2 | WELDED | ROUND | 42 | 40
InPort_2051025 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 18 | 15
OutPort_2051241 | Flow | SOURCEANDSINK | nový 102
InPort_2051025 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 18 | 15
OutPort_2051060 | Flow | SOURCEANDSINK | nový 102 | 1 | WELDED | ROUND | 28 | 25
InPort_2051043 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
OutPort_2051060 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
InPort_2051060 | Flow | SOURCEANDSINK | nový 102 | 3 | WELDED | ROUND | 18 | 15
OutPort_2051061 | Flow | SOURCEANDSINK | nový 102 | 2 | WELDED | ROUND | 28 | 25
Port_2051241 | Flow | SOURCEANDSINK | nový 102
12 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 42 | 40
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 35 | 32
2 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 110 | 110
 |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 25 | 20
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 25 | 20
24 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 28 | 25
24 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 28 | 25
3 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 15 | 15
3 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 18 | 15
 |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 40 | 40
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 40 | 40
 |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 22 | 20
7 x  |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 20 | 20
7 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 20 | 20
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 32 | 32
10 x  |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 42 | 40
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 22 | 20
 |  | SOURCEANDSINK |  | 1 | WELDED | ROUND | 18 | 15
 |  | SOURCEANDSINK |  | 2 | WELDED | ROUND | 15 | 15

# IfcEnergyConversionDevice: Pískový filtr:Pískový filtr, Pískový filtr:Pískový filtr:2013877
In: 1.NP
Type - Pset_BuildingElementProxyCommon - Reference: Pískový filtr
Type - Pset_QuantityTakeOff - Reference: Pískový filtr
Pset_BuildingElementProxyCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcEnergyConversionDevice: Tlaková nádoba PWB_100LH_EP:Tlaková nádoba PWB_100LH_EP, Tlaková nádoba PWB_100LH_EP:Tlaková nádoba PWB_100LH_EP:2007582
In: 1.NP
Type - Pset_BuildingElementProxyCommon - Reference: Tlaková nádoba PWB_100LH_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Tlaková nádoba PWB_100LH_EP
Pset_BuildingElementProxyCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Tlaková nádoba; SNIM: EN.02 Expanzní nádoba
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: nový 117

# IfcEnergyConversionDevice: UV lampa IBP HO30_EP:UV lampa IBP HO30_EP, UV lampa IBP HO30_EP:UV lampa IBP HO30_EP:2026338
In: 1.NP
Type - Pset_BuildingElementProxyCommon - Reference: UV lampa IBP HO30_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: UV lampa IBP HO30_EP
Pset_BuildingElementProxyCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: nový 103

# IfcEnergyConversionDevice: UV lampa UVH2_EP:UV lampa UVH2_EP, UV lampa UVH2_EP:UV lampa UVH2_EP:2015882
In: 1.NP
Type - Pset_BuildingElementProxyCommon - Reference: UV lampa UVH2_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: UV lampa UVH2_EP
Pset_BuildingElementProxyCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: nový 117

# IfcFlowFitting: HT_Koleno.CC:HT_Koleno.CC (10)
In: 1.NP
Type - Material: Trubky_HT Systém PP
Type - Pset_DistributionFlowElementCommon - Reference: HT_Koleno.CC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Osma
Type - Pset_QuantityTakeOff - Reference: HT_Koleno.CC
Classification: TT.01 Koleno (Default Classification); Trubní tvarovka (Uniformat)
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.01 Koleno
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (HT_Koleno.CC:HT_Koleno.CC:...) | Group
2032332 | nový 79
2032356 | nový 79
2032369 | nový 79
2032449 | nový 15
2032760 | nový 15
2032784 | nový 15
2032886 | nový 15
2032898 | nový 15
2032931 | nový 15
2033034 | nový 15

# IfcFlowFitting: HT_Odbočka.CC:HT_Odbočka.CC, HT_Odbočka.CC:HT_Odbočka.CC:2032755
In: 1.NP
Type - Material: Trubky_HT Systém PP
Type - Pset_DistributionFlowElementCommon - Reference: HT_Odbočka.CC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Osma
Type - Pset_QuantityTakeOff - Reference: HT_Odbočka.CC
Classification: Trubní tvarovka (Uniformat); TT.02 Odbočka (Default Classification); Group: nový 15
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Trubní tvarovka; SNIM: TT.02 Odbočka
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcFlowFitting: Sanpress_SC_Elbows_Viega1:Standard 2 (60)
Type - Description: Sanpress Bend; PredefinedType: BEND; Material: gunmetal
Type - Pset_DistributionFlowElementCommon - Reference: Standard 2
Type - Pset_ManufacturerTypeInformation - Manufacturer: Viega
Type - Pset_QuantityTakeOff - Reference: Standard 2
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Sanpress_SC_Elbows_Viega1:Standard 2:...) | In | NominalDiameter | Group
2010007 | 2.NP | 25 | nový 117
2010445 | 2.NP | 25 | nový 117
2010470 | 2.NP | 25 | nový 117
2010482 | 2.NP | 25 | nový 117
2010829 | 1.NP | 25 | nový 117
2010837 | 1.NP | 25 | nový 117
2012118 | 1.NP | 25 | nový 117
2012354 | 1.NP | 25 | nový 117
2014180 | 1.NP | 25 | nový 117
2014182 | 1.NP | 25 | nový 117
2014241 | 1.NP | 25 | nový 117
2014264 | 1.NP | 25 | nový 117
2014771 | 1.NP | 25 | nový 117
2015048 | 1.NP | 25 | nový 117
2016388 | 1.NP | 25 | nový 117
2017022 | 1.NP | 25 | nový 117
2017642 | 1.NP | 20 | nový 117
2018300 | 1.NP | 25 | nový 117
2018304 | 1.NP | 25 | nový 117
2020108 | 1.NP | 25 | nový 117
2020123 | 1.NP | 25 | nový 117
2020135 | 1.NP | 25 | nový 117
2020177 | 1.NP | 25 | nový 117
2020271 | 1.NP | 25 | nový 117
2020316 | 1.NP | 25 | nový 117
2020544 | 1.NP | 25 | nový 117
2023120 | 1.NP | 25 | nový 117
2023291 | 1.NP | 25 | nový 63
2023303 | 1.NP | 25 | nový 63
2023445 | 1.NP | 25 | nový 117
2023504 | 1.NP | 25 | nový 63
2023591 | 1.NP | 25 | nový 63
2024056 | 1.NP | 40 | nový 63
2024147 | 1.NP | 25 | nový 63
2024775 | 1.NP | 40 | nový 63
2025143 | 1.NP | 40 | nový 63
2025224 | 1.NP | 40 | nový 103
2025226 | 1.NP | 25 | nový 103
2025230 | 1.NP | 25 | nový 103
2025951 | 1.NP | 40 | nový 103
2026100 | 1.NP | 40 | nový 103
2026486 | 1.NP | 40 | nový 103
2027436 | 1.NP | 40 | nový 103
2027603 | 1.NP | 40 | nový 103
2028468 | 1.NP | 40 | nový 103
2028621 | 1.NP | 40 | nový 103
2028906 | 1.NP | 40 | nový 103
2028925 | 1.NP | 40 | nový 103
2029366 | 1.NP | 25 | nový 102
2029373 | 1.NP | 25 | nový 102
2029385 | 1.NP | 25 | nový 102
2029435 | 1.NP | 25 | nový 102
2029442 | 1.NP | 25 | nový 102
2029454 | 1.NP | 25 | nový 102
2030303 | 1.NP | 25 | nový 63
2030335 | 1.NP | 25 | nový 63
2031127 | 1.NP | 25 | nový 146
2031470 | 1.NP | 25 | nový 102
2031480 | 1.NP | 25 | nový 102
2031511 | 1.NP | 25 | nový 102

# IfcFlowFitting: Sanpress_SC_Reducer_Viega1:Standard 2 (20)
Type - Description: Sanpress Reducer; PredefinedType: TRANSITION; Material: gunmetal
Type - Pset_DistributionFlowElementCommon - Reference: Standard 2
Type - Pset_ManufacturerTypeInformation - Manufacturer: Viega
Type - Pset_QuantityTakeOff - Reference: Standard 2
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Sanpress_SC_Reducer_Viega1:Standard 2:...) | In | Group
2010005 | 1.NP | nový 117
2017026 | 1.NP | nový 117
2017709 | 1.NP | nový 117
2020548 | 1.NP | nový 117
2020588 | 1.NP | nový 117
2023293 | 1.NP | nový 63
2023297 | 1.NP | nový 63
2023593 | 1.NP | nový 63
2023999 | 1.NP | nový 63
2025220 | 1.NP | nový 103
2029375 | 1.NP | nový 102
2029379 | 1.NP | nový 102
2029444 | 1.NP | nový 102
2029448 | 1.NP | nový 102
2030307 | 1.NP | nový 63
2030333 | NEHMOTNÉ POLOŽKY | nový 63
2031129 | 1.NP | nový 146; nový 144
2031173 | 1.NP | nový 103; nový 144
2031616 | 1.NP | nový 102
2050724 | 3.NP | nový 63

# IfcFlowFitting: Sanpress_SC_T-pieces_Viega1:Standard 2 (15)
Type - Description: Sanpress Tee; PredefinedType: JUNCTION; Material: gunmetal
Type - Pset_DistributionFlowElementCommon - Reference: Standard 2
Type - Pset_ManufacturerTypeInformation - Manufacturer: Viega
Type - Pset_QuantityTakeOff - Reference: Standard 2
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Sanpress_SC_T-pieces_Viega1:Standard 2:...) | In | Group
2010403 | 2.NP | nový 117
2011704 | 2.NP | nový 117
2012350 | 1.NP | nový 117
2012731 | 1.NP | nový 117
2015044 | 1.NP | nový 117
2016390 | 1.NP | nový 117
2018201 | 1.NP | nový 117
2018296 | 1.NP | nový 117
2028433 | 1.NP | nový 103
2028617 | 1.NP | nový 103
2031507 | 1.NP | nový 102
2031815 | 1.NP | nový 117
2039988 | 1.NP | nový 103
2050729 | 3.NP | nový 63
2051060 | 3.NP | nový 102

# IfcFlowFitting: Vodárna_EP:Vodárna_EP (2)
In: 1.NP
Type - Pset_DistributionFlowElementCommon - Reference: Vodárna_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Vodárna_EP
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Čerpadlo
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Vodárna_EP:Vodárna_EP:...) | Group
2023793 | nový 63
2025215 | nový 103

# IfcFlowMovingDevice: Domovní vodoměr_EP:Domovní vodoměr_EP (7)
In: NEHMOTNÉ POLOŽKY
Type - Pset_DistributionFlowElementCommon - Reference: Domovní vodoměr_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Domovní vodoměr_EP
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Domovní vodoměr_EP:Domovní vodoměr_EP:...) | Group
2019931 | nový 117
2020448 | nový 117
2023290 | nový 63
2029372 | nový 102
2029441 | nový 102
2030215 | nový 63
2031087 | nový 144

# IfcFlowMovingDevice: Filtr LTFI_Y1_EP:Filtr LTFI_Y1_EP, Filtr LTFI_Y1_EP:Filtr LTFI_Y1_EP:2009466
In: 1.NP
Type - Pset_DistributionFlowElementCommon - Reference: Filtr LTFI_Y1_EP
Type - Pset_ManufacturerTypeInformation - Manufacturer: Výrobce
Type - Pset_QuantityTakeOff - Reference: Filtr LTFI_Y1_EP
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Filtr; SNIM: FI.02 Mechanický
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Group: nový 117

# IfcFlowMovingDevice: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout (27)
Type - Pset_DistributionFlowElementCommon - Reference: Kulový kohout
Type - Pset_QuantityTakeOff - Reference: Kulový kohout
Pset_DistributionFlowElementCommon - sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout:...) | In | OZNAČENÍ | SNIM | Group
2011351 | 2.NP | Ventil | VE.01 Kulový kohout | nový 117
2010713 | 2.NP | Ventil | VE.01 Kulový kohout | nový 117
2015361 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2012191 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2012644 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2014864 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2015162 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2017874 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2018011 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2018357 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2020796 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2023299 | 1.NP | Ventil | VE.01 Kulový kohout | nový 63
2024440 | 1.NP | Ventil | VE.01 Kulový kohout | nový 63
2024660 | 1.NP | Ventil | VE.01 Kulový kohout | nový 63
2025234 | 1.NP | Ventil | VE.01 Kulový kohout | nový 103
2031265 | 1.NP | Ventil | VE.01 Kulový kohout | nový 146
2025237 | 1.NP | Ventil | VE.01 Kulový kohout | nový 103
2027128 | 1.NP | Ventil | VE.01 Kulový kohout | nový 103
2027640 | 1.NP | Ventil | VE.01 Kulový kohout | nový 103
2028714 | 1.NP | Ventil | VE.01 Kulový kohout | nový 103
2029381 | 1.NP | Ventil | VE.01 Kulový kohout | nový 102
2029450 | 1.NP | Ventil | VE.01 Kulový kohout | nový 102
