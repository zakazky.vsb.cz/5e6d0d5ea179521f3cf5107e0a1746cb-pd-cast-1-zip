Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowMovingDevice: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout (27)
Name (Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout:...) | In | OZNAČENÍ | SNIM | Group
2030364 | 1.NP | Ventil | VE.01 Kulový kohout | nový 63
2031972 | 1.NP | Ventil | VE.01 Kulový kohout | nový 117
2040033 | 1.NP | Ventil | VE.01 Kulový kohout | nový 103
2050478 | 3.NP |  |  | nový 63
2051241 | 3.NP |  |  | nový 102

# IfcFlowMovingDevice: Zpětný ventil_DN10_DN100_EP:DN40 (2)
In: 1.NP
Type - Pset_DistributionFlowElementCommon - Reference: DN40
Type - Pset_QuantityTakeOff - Reference: DN40
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil; SNIM: VE.15 Zpětný
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (Zpětný ventil_DN10_DN100_EP:DN40:...) | Group
2031007 | nový 63
2030905 | nový 103

# IfcFlowMovingDevice: d9505-dn50-rfa_2019:D9505 DN25 (4)
In: NEHMOTNÉ POLOŽKY
Type - Pset_DistributionFlowElementCommon - Reference: D9505 DN25
Type - Pset_ManufacturerTypeInformation - Manufacturer: Hydronic Systems Prague s.r.o.
Type - Pset_QuantityTakeOff - Reference: D9505 DN25
Pset_DistributionFlowElementCommon - sets with these values: 2
REVIT Klasifikace - OZNAČENÍ: Ventil
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
Name (d9505-dn50-rfa_2019:D9505 DN25:...) | Group
2023016 | nový 117
2023302 | nový 63
2029384 | nový 102
2029453 | nový 102

# IfcFlowSegment: Plast - HT (13)
In: 1.NP
Type - ElementType: Plast - HT; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 110; OuterDiameter: 110
Pset_DistributionFlowElementCommon - Reference: Plast - HT; sets with these values: 2
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:Plast - HT:...) | Length (mm) | Group
2032336 | 107 | nový 79
2032350 | 135.284 | nový 79
2032360 | 1102 | nový 79 | Classification: TR.08 Polypropylen (PP) (Default Classification); Trubka (Uniformat); REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.08 Polypropylen (PP)
2032410 | 162.997 | nový 15
2032550 | 82.758 | nový 15
2032587 | 80 | nový 15
2032740 | 7.64283 | nový 15
2032756 | 794.754 | nový 15 | Classification: TR.08 Polypropylen (PP) (Default Classification); Trubka (Uniformat); REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.08 Polypropylen (PP)
2032776 | 378.22 | nový 15 | Classification: TR.08 Polypropylen (PP) (Default Classification); Trubka (Uniformat); REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.08 Polypropylen (PP)
2032875 | 142 | nový 15
2032902 | 108.051 | nový 15
2032933 | 72 | nový 15
2032999 | 65.5 | nový 15

# IfcFlowSegment: Sanpress (4)
Type - ElementType: Sanpress; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 15; OuterDiameter: 18
Pset_DistributionFlowElementCommon - Reference: Sanpress; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Viega
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:Sanpress:...) | In | Length (mm) | Group
2012369 | 1.NP | 26 | nový 117
2031800 | 1.NP | 20.7298 | nový 117
2050174 | 3.NP | 27 | nový 63
2051025 | 3.NP | 23.5 | nový 102

# IfcFlowSegment: Sanpress (4)
Type - ElementType: Sanpress; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 20; OuterDiameter: 22
Pset_DistributionFlowElementCommon - Reference: Sanpress; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Viega
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:Sanpress:...) | In | Length (mm) | Group
2017571 | 1.NP | 19 | nový 117
2017636 | 1.NP | 13 | nový 117
2039944 | 1.NP | 40.5 | nový 103
2050710 | 3.NP | 9.91589 | nový 63

# IfcFlowSegment: Sanpress (98)
Type - ElementType: Sanpress; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 25; OuterDiameter: 28
Pset_DistributionFlowElementCommon - Reference: Sanpress; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Viega
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:Sanpress:...) | In | Length (mm) | Group
2009723 | 2.NP | 33.9 | nový 117
2009975 | 2.NP | 142 | nový 117
2009983 | 2.NP | 161.1 | nový 117
2009993 | 2.NP | 113.341 | nový 117
2010022 | 1.NP | 41.2999 | nový 117
2010423 | 2.NP | 98 | nový 117
2010436 | 2.NP | 212.218 | nový 117
2010462 | 2.NP | 87.0253 | nový 117
2010472 | 2.NP | 80.6754 | nový 117
2010725 | 2.NP | 64.25 | nový 117
2010821 | 1.NP | 56 | nový 117
2010841 | 1.NP | 70.7135 | nový 117
2011353 | 2.NP | 20.3999 | nový 117
2012097 | 1.NP | 88 | nový 117
2012110 | 1.NP | 271.95 | nový 117
2012132 | 1.NP | 88 | nový 117
2012212 | 1.NP | 213.05 | nový 117
2012351 | 1.NP | 18.4501 | nový 117
2012387 | 1.NP | 79.9897 | nový 117
2012732 | 1.NP | 108.742 | nový 117
2014178 | 1.NP | 834.23 | nový 117
2014233 | 1.NP | 147.23 | nový 117
2014258 | 1.NP | 8 | nový 117
2014288 | 1.NP | 153.56 | nový 117
2014886 | 1.NP | 52.25 | nový 117
2014978 | 1.NP | 63 | nový 117
2014991 | 1.NP | 108.677 | nový 117
2015032 | 1.NP | 987.554 | nový 117
2015045 | 1.NP | 55.9918 | nový 117
2015197 | 1.NP | 274.25 | nový 117
2015374 | 1.NP | 80.2135 | nový 117
2016383 | 1.NP | 31 | nový 117
2016391 | 1.NP | 57.75 | nový 117
2016614 | 1.NP | 19.0557 | nový 117
2016913 | 1.NP | 26.7824 | nový 117
2017646 | 1.NP | 48.3966 | nový 117
2017897 | 1.NP | 67.4676 | nový 117
2018028 | 1.NP | 31.8316 | nový 117
2018275 | 1.NP | 423 | nový 117
2018283 | 1.NP | 158.304 | nový 117
2018294 | 1.NP | 19.0557 | nový 117
2018297 | 1.NP | 8.35343 | nový 117
2018359 | 1.NP | 206.935 | nový 117
2018698 | 1.NP | 494.728 | nový 117
2020068 | 1.NP | 37.9358 | nový 117
2020113 | 1.NP | 256 | nový 117
2020127 | 1.NP | 971.385 | nový 117
2020171 | 1.NP | 956 | nový 117
2020255 | 1.NP | 490 | nový 117
2020298 | 1.NP | 320.242 | nový 117
2020308 | 1.NP | 95.4766 | nový 117
2020344 | 1.NP | 24.1143 | nový 117
2020356 | 1.NP | 27.5 | nový 117
2020557 | 1.NP | 31.6143 | nový 117
2020798 | 1.NP | 912.023 | nový 117
2023127 | 1.NP | 95 | nový 117
2023282 | 1.NP | 95.4766 | nový 63
2023286 | 1.NP | 24.1143 | nový 63
2023288 | 1.NP | 27.5 | nový 63
2023295 | 1.NP | 31.6143 | nový 63
2023300 | 1.NP | 912.023 | nový 63
2023305 | 1.NP | 95 | nový 63
2023496 | 1.NP | 570.209 | nový 63
2023577 | 1.NP | 71.0615 | nový 63
2023950 | 1.NP | 11 | nový 63
2024151 | 1.NP | 29.0916 | nový 63
2024305 | 1.NP | 10.3506 | nový 63
2024311 | 1.NP | 58 | nový 63
2024442 | 1.NP | 75.9084 | nový 63
2025218 | 1.NP | 11 | nový 103
2025228 | 1.NP | 29.0916 | nový 103
2025232 | 1.NP | 38.3994 | nový 146
2025235 | 1.NP | 75.9084 | nový 103
2025645 | 1.NP | 57.883 | nový 146
2029362 | 1.NP | 423.574 | nový 102
2029364 | 1.NP | 95.4766 | nový 102
2029368 | 1.NP | 24.1143 | nový 102
2029370 | 1.NP | 27.5 | nový 102
2029377 | 1.NP | 31.6143 | nový 102
2029382 | 1.NP | 912.023 | nový 102
2029387 | 1.NP | 95 | nový 102
2029431 | 1.NP | 423.574 | nový 102
2029433 | 1.NP | 95.4766 | nový 102
2029437 | 1.NP | 24.1143 | nový 102
2029439 | 1.NP | 27.5 | nový 102
2029446 | 1.NP | 31.6143 | nový 102
2029451 | 1.NP | 982.832 | nový 102
2029456 | 1.NP | 95 | nový 102
2030319 | 1.NP | 26.8487 | nový 63
2030366 | 1.NP | 51.3007 | nový 63
2031161 | 1.NP | 10.3506 | nový 103
2031300 | 1.NP | 39.75 | nový 146
2031458 | 1.NP | 36 | nový 102
2031493 | 1.NP | 109.808 | nový 102
2031508 | 1.NP | 806.763 | nový 102
2031816 | 1.NP | 157.272 | nový 117
2051043 | 1.NP | 154.319 | nový 102
2051061 | 1.NP | 288.89 | nový 102

# IfcFlowSegment: Sanpress, Typy trubek:Sanpress:2031582
In: 1.NP
Type - ElementType: Sanpress; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 32; OuterDiameter: 35
Pset_DistributionFlowElementCommon - Reference: Sanpress; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Viega
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentPipeSegment - Length: 45.6892 mm
Group: nový 102

# IfcFlowSegment: Sanpress (30)
In: 1.NP
Type - ElementType: Sanpress; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 40; OuterDiameter: 42
Pset_DistributionFlowElementCommon - Reference: Sanpress; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Viega
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name (Typy trubek:Sanpress:...) | Length (mm) | Group
2023941 | 33 | nový 63
2024036 | 85 | nový 63
2024671 | 98.018 | nový 63
2024757 | 1820.61 | nový 63
2024765 | 492.488 | nový 63
2025081 | 114.567 | nový 63
2025216 | 33 | nový 103
2025222 | 5 | nový 103
2025238 | 98.018 | nový 103
2025937 | 2200.98 | nový 103
2026086 | 1268.32 | nový 103
2026452 | 65 | nový 103
2026466 | 59.1868 | nový 103
2026476 | 88.0885 | nový 103
2027130 | 1064.89 | nový 103
2027579 | 65 | nový 103
2027642 | 53.6196 | nový 103
2028427 | 47.1156 | nový 103
2028434 | 86.7653 | nový 103
2028460 | 128.383 | nový 103
2028586 | 47.1157 | nový 103
2028618 | 854.478 | nový 103
2028737 | 49.4974 | nový 103
2028892 | 447.495 | nový 103
2028900 | 602.751 | nový 103
2028910 | 79.5048 | nový 103
2030939 | 119.993 | nový 103
2031026 | 119.993 | nový 63
2039989 | 50.12 | nový 103
2050730 | 212.887 | nový 63

# IfcFlowSegment: Smartpress, Typy trubek:Smartpress:2044569
In: 3.NP
Type - ElementType: Smartpress; PredefinedType: RIGIDSEGMENT
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 20; OuterDiameter: 25
Classification: Trubka (Uniformat); TR.04 Ocel nerezová (Default Classification)
Pset_DistributionFlowElementCommon - Reference: Smartpress; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Viega
REVIT Klasifikace - OZNAČENÍ: Trubka; SNIM: TR.04 Ocel nerezová
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_FlowSegmentPipeSegment - Length: 58.318 mm

# IfcBuildingElementProxyType, no part of this type: Pískový filtr:Pískový filtr
Material: Fiberglass-WATTS

# IfcPipeSegmentType, no part of this type: Typy trubek:Sanpress
Material: Změkčená voda
Pset_DistributionFlowElementCommon - Reference: Sanpress
Pset_ManufacturerTypeInformation - Manufacturer: Viega
Pset_QuantityTakeOff - Reference: Sanpress

# IfcPipeSegmentType, no part of this type: Typy trubek:Smartpress
Material: PPR studená voda
Pset_DistributionFlowElementCommon - Reference: Smartpress
Pset_ManufacturerTypeInformation - Manufacturer: Viega
Pset_QuantityTakeOff - Reference: Smartpress

# IfcValveType, no part of this type: Domovní vodoměr_EP:Domovní vodoměr_EP
Material: <Unnamed>

# IfcValveType, no part of this type: Domovní vodoměr_EP:Domovní vodoměr_EP
Material: <Unnamed>

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio

# IfcValveType, no part of this type: Kulový kohout parametrický_DN10_DN100_EP:Kulový kohout
Material: STH_Aluminio
